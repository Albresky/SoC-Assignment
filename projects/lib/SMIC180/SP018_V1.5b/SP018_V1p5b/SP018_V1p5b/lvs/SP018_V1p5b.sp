************************************************************************************
* SPICE netlist:                                                                   *
* Library  name: SP018_V1p5b                                                       *
* Release: May. 4 2011 Jie_Sun                                                     *
************************************************************************************
* Verify:                                                                          *
*                                                                                  *
* Hercules:                                                                        *
* SmicSP7P_her018_log_p1mx_sali.lvs                                                *
* Revision: 1.29 2004/06/18                                                        *
*                                                                                  *
* Calibre:                                                                         *
* SmicSP7P_cal018_log_p1mtx_sali.lvs                                               *
* revision: 1.12 2004/04/20                                                        *
************************************************************************************
*   MODEL NAME:                                                                    *
*        HERCULES DRACULA Calibre                                                  *
*        N18      N       N18           1.8V NMOS                                  *
*        N33      NH      N33           3.3V NMOS                                  *
*        C2       C2      C2            3.3V NMOS in NWELL                         *
*        P18      P       P18           1.8V PMOS                                  *
*        P33      PH      P33           3.3V PMOS                                  *
*        PDIO33   D1      PDIO33        3.3V diode P+/NW                           *
************************************************************************************
*  FOR HERCULES ,PLEASE add FP in the group of schematic global in option section  *
*  of  the runset file as shown in the settings below:                             *
*  options {                                                                       *
*  layout_power = {VDD,VDD33}                                                      *
*  layout_ground = {VSS,VSSD}                                                      *
*  layout_global = {VDD,VSS,VDD33,VSSD}                                            *
*  schematic_power = {VDD,VDD33}                                                   *
*  schematic_ground = {VSSD,VSS}                                                   *
*  schematic_global = {VDD,VSS,VSSD,VDD33,FP}                                      *
*  }                                                                               *
************************************************************************************
*///////////////////////////////////////////////////////////////////////////////////
*//DISCLAIMER                                                                     //
*//                                                                               //
*//   SMIC hereby provides the quality information to you but makes no claims,    //
*// promises or guarantees about the accuracy, completeness, or adequacy of the   //
*// information herein. The information contained herein is provided on an "AS IS"//
*// basis without any warranty, and SMIC assumes no obligation to provide support //
*// of any kind or otherwise maintain the information.                            //
*//                                                                               //
*//   SMIC disclaims any representation that the information does not infringe any//
*// intellectual property rights or proprietary rights of any third parties.SMIC  //
*// makes no other warranty, whether express, implied or statutory as to any      //
*// matter whatsoever,including but not limited to the accuracy or sufficiency of //
*// any information or the merchantability and fitness for a particular purpose.  //
*// Neither SMIC nor any of its representatives shall be liable for any cause of  //
*// action incurred to connect to this service.                                   //
*//                                                                               //
*//                                                                               //
*// STATEMENT OF USE AND CONFIDENTIALITY                                          //
*//                                                                               //
*//   The following/attached material contains confidential and proprietary       //
*// information of SMIC. This material is based upon information which SMIC       //
*// considers reliable, but SMIC neither represents nor warrants that such        //
*// information is accurate or complete, and it must not be relied upon as such.  //
*// This information was prepared for informational purposes and is for the use   //
*// by SMIC's customer only. SMIC reserves the right to make changes in the       //
*// information at any time without notice.                                       //
*//   No part of this information may be reproduced, transmitted, transcribed,    //
*// stored in a retrieval system, or translated into any human or computer        //
*// language, in any form or by any means, electronic, mechanical, magnetic,      //
*// optical, chemical, manual, or otherwise, without the prior written consent of //
*// SMIC. Any unauthorized use or disclosure of this material is strictly         //
*// prohibited and may be unlawful. By accepting this material, the receiving     //
*// party shall be deemed to have acknowledged, accepted, and agreed to be bound  //
*// by the foregoing limitations and restrictions. Thank you.                     //
************************************************************************************
*.BIPOLAR
************************************************************************************
************************************************************************************
.GLOBAL VDD:P VSS:G VDD33:P VSSD:G SAVDD:P SAVSS:G SAVDD33:P SAVSSD:G FP:P

.subckt PXWE3   XIN XOUT XC E FP
M1 VSS E NET_64 VSS N18 l=0.180u w=4.000u
M2 VSS E NET_64 VSS N18 l=0.180u w=4.000u
M3 VSS NET_92 XC VSS N18 l=0.180u w=2.000u
M4 VSS NET_92 XC VSS N18 l=0.180u w=2.000u
M5 XC NET_92 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_92 XC VSS N18 l=0.180u w=2.000u
M7 XC NET_92 VSS VSS N18 l=0.180u w=2.000u
M8 XC NET_92 VSS VSS N18 l=0.180u w=2.000u
M9 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M10 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M11 XC NET_92 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M13 XC NET_92 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M15 XC NET_92 VDD VDD P18 l=0.180u w=5.000u
M16 VDD E NET_64 VDD P18 l=0.300u w=5.000u
M17 NET_64 E VDD VDD P18 l=0.300u w=5.000u
M18 VDD E NET_64 VDD P18 l=0.300u w=5.000u
M19 VDD E NET_64 VDD P18 l=0.300u w=5.000u
M20 NET_59 NET_64 VSS VSS N33 l=0.350u w=8.000u
M21 NET_59 NET_64 VSS VSS N33 l=0.350u w=8.000u
M22 VSS E NET_57 VSS N33 l=0.350u w=8.000u
M23 VSS NET_57 NET_60 VSS N33 l=0.350u w=4.000u
M24 VSS NET_57 NET_60 VSS N33 l=0.350u w=4.000u
M25 NET_60 NET_57 VSS VSS N33 l=0.350u w=4.000u
M26 NET_57 E VSS VSS N33 l=0.350u w=8.000u
M27 NET_84 NET_82 VDD33 VSS N33 l=0.350u w=4.500u
M28 NET_84 NET_81 NET_82 VSS N33 l=0.350u w=8.000u
M29 NET_84 NET_81 VSS VSS N33 l=0.350u w=8.000u
M30 VSS NET_82 NET_92 VSS N33 l=0.350u w=2.000u
M31 VSS NET_82 NET_92 VSS N33 l=0.350u w=2.000u
M32 NET_74 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M33 NET_74 FP XOUT VSSD N33 l=0.400u w=28.000u
M34 NET_80 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M35 NET_80 FP XOUT VSSD N33 l=0.400u w=28.000u
M36 XOUT FP NET_72 VSSD N33 l=0.400u w=28.000u
M37 NET_72 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M38 VSSD NET_7 NET_70 VSSD N33 l=0.400u w=28.000u
M39 NET_70 FP XOUT VSSD N33 l=0.400u w=28.000u
M40 NET_47 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M41 NET_47 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M42 VSSD NET_38 NET_45 VSSD N33 l=0.400u w=28.000u
M43 NET_45 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M44 XOUT FP NET_78 VSSD N33 l=0.400u w=28.000u
M45 NET_78 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_7 NET_76 VSSD N33 l=0.400u w=28.000u
M47 NET_76 FP XOUT VSSD N33 l=0.400u w=28.000u
M48 NET_54 FP XOUT VSSD N33 l=0.400u w=28.000u
M49 NET_54 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_38 NET_52 VSSD N33 l=0.400u w=28.000u
M51 NET_52 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M52 NET_7 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M53 XOUT NET_60 NET_43 VSSD N33 l=0.400u w=28.000u
M54 NET_43 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_38 NET_41 VSSD N33 l=0.400u w=28.000u
M56 NET_41 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M57 XOUT NET_60 NET_11 VSSD N33 l=0.400u w=28.000u
M58 NET_11 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M59 XOUT NET_60 NET_50 VSSD N33 l=0.400u w=28.000u
M60 NET_50 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M61 VSSD NET_38 NET_48 VSSD N33 l=0.400u w=28.000u
M62 NET_48 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M63 XOUT NET_60 NET_12 VSSD N33 l=0.400u w=28.000u
M64 NET_12 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M65 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M66 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M68 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M70 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M72 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M74 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M76 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M78 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_29 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M80 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M81 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M82 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M83 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M84 NET_92 NET_82 VDD VDD P33 l=0.300u w=5.000u
M85 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M86 NET_92 NET_82 VDD VDD P33 l=0.300u w=5.000u
M87 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M88 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M89 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M90 VSS NET_82 NET_7127 VDD33 P33 l=0.300u w=5.000u
M91 VSS NET_82 NET_7127 VDD33 P33 l=0.300u w=5.000u
M92 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M93 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M94 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M95 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M96 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M97 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M98 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M99 VDD33 VSS NET_7117 VDD33 P33 l=0.300u w=5.000u
M100 VDD33 VSS NET_7109 VDD33 P33 l=0.300u w=5.000u
M101 NET_7127 NET_81 NET_82 VDD33 P33 l=0.300u w=5.000u
M102 NET_7127 NET_81 NET_82 VDD33 P33 l=0.300u w=5.000u
M103 NET_7127 NET_81 NET_82 VDD33 P33 l=0.300u w=5.000u
M104 NET_7127 NET_81 VDD33 VDD33 P33 l=0.300u w=5.000u
M105 VDD33 NET_81 NET_7127 VDD33 P33 l=0.300u w=5.000u
M106 NET_7127 NET_81 VDD33 VDD33 P33 l=0.300u w=5.000u
M107 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M108 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M109 XOUT NET_38 VDD33 VDD33 P33 l=0.300u w=30.000u
M110 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M111 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M112 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M113 XOUT NET_38 VDD33 VDD33 P33 l=0.300u w=30.000u
M114 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M115 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M116 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M117 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M118 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M119 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M120 NET_60 NET_57 VDD33 VDD33 P33 l=0.300u w=5.000u
M121 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M122 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M125 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M126 XOUT NET_60 VDD33 VDD33 P33 l=0.300u w=30.000u
M127 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M128 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M129 XOUT NET_60 VDD33 VDD33 P33 l=0.300u w=30.000u
M130 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M131 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M132 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M133 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M134 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M135 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M136 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M137 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M138 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M139 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M140 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M141 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M142 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M143 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M144 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M145 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M146 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M147 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M148 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M149 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M150 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M151 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M152 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M153 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
R1 XOUT NET_81 300.135
R2 XIN NET_38 300.135
.ends PXWE3

.subckt PXWE2   XIN XOUT XC E FP
M1 VSS E NET_64 VSS N18 l=0.180u w=4.000u
M2 VSS E NET_64 VSS N18 l=0.180u w=4.000u
M3 VSS NET_92 XC VSS N18 l=0.180u w=2.000u
M4 VSS NET_92 XC VSS N18 l=0.180u w=2.000u
M5 XC NET_92 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_92 XC VSS N18 l=0.180u w=2.000u
M7 XC NET_92 VSS VSS N18 l=0.180u w=2.000u
M8 XC NET_92 VSS VSS N18 l=0.180u w=2.000u
M9 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M10 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M11 XC NET_92 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M13 XC NET_92 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M15 XC NET_92 VDD VDD P18 l=0.180u w=5.000u
M16 VDD E NET_64 VDD P18 l=0.300u w=5.000u
M17 NET_64 E VDD VDD P18 l=0.300u w=5.000u
M18 VDD E NET_64 VDD P18 l=0.300u w=5.000u
M19 VDD E NET_64 VDD P18 l=0.300u w=5.000u
M20 NET_59 NET_64 VSS VSS N33 l=0.350u w=8.000u
M21 NET_59 NET_64 VSS VSS N33 l=0.350u w=8.000u
M22 VSS E NET_57 VSS N33 l=0.350u w=8.000u
M23 VSS NET_57 NET_60 VSS N33 l=0.350u w=4.000u
M24 VSS NET_57 NET_60 VSS N33 l=0.350u w=4.000u
M25 NET_60 NET_57 VSS VSS N33 l=0.350u w=4.000u
M26 NET_57 E VSS VSS N33 l=0.350u w=8.000u
M27 NET_84 NET_82 VDD33 VSS N33 l=0.350u w=4.500u
M28 NET_84 NET_81 NET_82 VSS N33 l=0.350u w=8.000u
M29 NET_84 NET_81 VSS VSS N33 l=0.350u w=8.000u
M30 VSS NET_82 NET_92 VSS N33 l=0.350u w=2.000u
M31 VSS NET_82 NET_92 VSS N33 l=0.350u w=2.000u
M32 NET_74 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M33 NET_74 FP XOUT VSSD N33 l=0.400u w=28.000u
M34 NET_80 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M35 NET_80 FP XOUT VSSD N33 l=0.400u w=28.000u
M36 XOUT FP NET_72 VSSD N33 l=0.400u w=28.000u
M37 NET_72 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M38 VSSD NET_7 NET_70 VSSD N33 l=0.400u w=28.000u
M39 NET_70 FP XOUT VSSD N33 l=0.400u w=28.000u
M40 NET_47 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M41 NET_47 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M42 VSSD NET_38 NET_45 VSSD N33 l=0.400u w=28.000u
M43 NET_45 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M44 XOUT FP NET_78 VSSD N33 l=0.400u w=28.000u
M45 NET_78 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_7 NET_76 VSSD N33 l=0.400u w=28.000u
M47 NET_76 FP XOUT VSSD N33 l=0.400u w=28.000u
M48 NET_54 FP XOUT VSSD N33 l=0.400u w=28.000u
M49 NET_54 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_7 NET_52 VSSD N33 l=0.400u w=28.000u
M51 NET_52 FP XOUT VSSD N33 l=0.400u w=28.000u
M52 NET_7 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M53 XOUT NET_60 NET_43 VSSD N33 l=0.400u w=28.000u
M54 NET_43 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_38 NET_41 VSSD N33 l=0.400u w=28.000u
M56 NET_41 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M57 XOUT NET_60 NET_11 VSSD N33 l=0.400u w=28.000u
M58 NET_11 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M59 XOUT FP NET_50 VSSD N33 l=0.400u w=28.000u
M60 NET_50 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M61 VSSD NET_38 NET_48 VSSD N33 l=0.400u w=28.000u
M62 NET_48 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M63 XOUT NET_60 NET_12 VSSD N33 l=0.400u w=28.000u
M64 NET_12 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M65 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M66 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M68 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M70 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M72 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M74 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M76 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M78 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_29 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M80 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M81 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M82 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M83 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M84 NET_92 NET_82 VDD VDD P33 l=0.300u w=5.000u
M85 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M86 NET_92 NET_82 VDD VDD P33 l=0.300u w=5.000u
M87 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M88 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M89 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M90 VSS NET_82 NET_7127 VDD33 P33 l=0.300u w=5.000u
M91 VSS NET_82 NET_7127 VDD33 P33 l=0.300u w=5.000u
M92 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M93 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M94 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M95 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M96 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M97 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M98 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M99 VDD33 VSS NET_7117 VDD33 P33 l=0.300u w=5.000u
M100 VDD33 VSS NET_7109 VDD33 P33 l=0.300u w=5.000u
M101 NET_7127 NET_81 NET_82 VDD33 P33 l=0.300u w=5.000u
M102 NET_7127 NET_81 NET_82 VDD33 P33 l=0.300u w=5.000u
M103 NET_7127 NET_81 NET_82 VDD33 P33 l=0.300u w=5.000u
M104 NET_7127 NET_81 VDD33 VDD33 P33 l=0.300u w=5.000u
M105 VDD33 NET_81 NET_7127 VDD33 P33 l=0.300u w=5.000u
M106 NET_7127 NET_81 VDD33 VDD33 P33 l=0.300u w=5.000u
M107 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M108 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M109 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M110 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M111 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M112 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M113 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M114 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M115 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M116 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M117 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M118 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M119 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M120 NET_60 NET_57 VDD33 VDD33 P33 l=0.300u w=5.000u
M121 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M122 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M125 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M126 XOUT NET_60 VDD33 VDD33 P33 l=0.300u w=30.000u
M127 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M128 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M129 XOUT NET_60 VDD33 VDD33 P33 l=0.300u w=30.000u
M130 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M131 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M132 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M133 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M134 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M135 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M136 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M137 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M138 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M139 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M140 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M141 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M142 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M143 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M144 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M145 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M146 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M147 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M148 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M149 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M150 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M151 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M152 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M153 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
R1 XOUT NET_81 300.135
R2 XIN NET_38 300.135
.ends PXWE2

.subckt PXWE1   XIN XOUT XC E FP
M1 VSS E NET_64 VSS N18 l=0.180u w=4.000u
M2 VSS E NET_64 VSS N18 l=0.180u w=4.000u
M3 VSS NET_92 XC VSS N18 l=0.180u w=2.000u
M4 VSS NET_92 XC VSS N18 l=0.180u w=2.000u
M5 XC NET_92 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_92 XC VSS N18 l=0.180u w=2.000u
M7 XC NET_92 VSS VSS N18 l=0.180u w=2.000u
M8 XC NET_92 VSS VSS N18 l=0.180u w=2.000u
M9 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M10 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M11 XC NET_92 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M13 XC NET_92 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_92 XC VDD P18 l=0.180u w=5.000u
M15 XC NET_92 VDD VDD P18 l=0.180u w=5.000u
M16 VDD E NET_64 VDD P18 l=0.300u w=5.000u
M17 NET_64 E VDD VDD P18 l=0.300u w=5.000u
M18 VDD E NET_64 VDD P18 l=0.300u w=5.000u
M19 VDD E NET_64 VDD P18 l=0.300u w=5.000u
M20 NET_59 NET_64 VSS VSS N33 l=0.350u w=8.000u
M21 NET_59 NET_64 VSS VSS N33 l=0.350u w=8.000u
M22 VSS E NET_57 VSS N33 l=0.350u w=8.000u
M23 VSS NET_57 NET_60 VSS N33 l=0.350u w=4.000u
M24 VSS NET_57 NET_60 VSS N33 l=0.350u w=4.000u
M25 NET_60 NET_57 VSS VSS N33 l=0.350u w=4.000u
M26 NET_57 E VSS VSS N33 l=0.350u w=8.000u
M27 NET_84 NET_82 VDD33 VSS N33 l=0.350u w=4.500u
M28 NET_84 NET_81 NET_82 VSS N33 l=0.350u w=8.000u
M29 NET_84 NET_81 VSS VSS N33 l=0.350u w=8.000u
M30 VSS NET_82 NET_92 VSS N33 l=0.350u w=2.000u
M31 VSS NET_82 NET_92 VSS N33 l=0.350u w=2.000u
M32 NET_74 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M33 NET_74 FP XOUT VSSD N33 l=0.400u w=28.000u
M34 NET_80 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M35 NET_80 FP XOUT VSSD N33 l=0.400u w=28.000u
M36 XOUT FP NET_72 VSSD N33 l=0.400u w=28.000u
M37 NET_72 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M38 VSSD NET_7 NET_70 VSSD N33 l=0.400u w=28.000u
M39 NET_70 FP XOUT VSSD N33 l=0.400u w=28.000u
M40 NET_47 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M41 NET_47 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M42 VSSD NET_38 NET_45 VSSD N33 l=0.400u w=28.000u
M43 NET_45 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M44 XOUT FP NET_78 VSSD N33 l=0.400u w=28.000u
M45 NET_78 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_7 NET_76 VSSD N33 l=0.400u w=28.000u
M47 NET_76 FP XOUT VSSD N33 l=0.400u w=28.000u
M48 NET_54 FP XOUT VSSD N33 l=0.400u w=28.000u
M49 NET_54 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_7 NET_52 VSSD N33 l=0.400u w=28.000u
M51 NET_52 FP XOUT VSSD N33 l=0.400u w=28.000u
M52 NET_7 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M53 XOUT NET_60 NET_43 VSSD N33 l=0.400u w=28.000u
M54 NET_43 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_38 NET_41 VSSD N33 l=0.400u w=28.000u
M56 NET_41 NET_60 XOUT VSSD N33 l=0.400u w=28.000u
M57 XOUT NET_60 NET_11 VSSD N33 l=0.400u w=28.000u
M58 NET_11 NET_38 VSSD VSSD N33 l=0.400u w=28.000u
M59 XOUT FP NET_50 VSSD N33 l=0.400u w=28.000u
M60 NET_50 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M61 VSSD NET_7 NET_48 VSSD N33 l=0.400u w=28.000u
M62 NET_48 FP XOUT VSSD N33 l=0.400u w=28.000u
M63 XOUT FP NET_12 VSSD N33 l=0.400u w=28.000u
M64 NET_12 NET_7 VSSD VSSD N33 l=0.400u w=28.000u
M65 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M66 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M68 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M70 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M72 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M74 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M76 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_29 XIN VSSD N33 l=0.400u w=28.000u
M78 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_29 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M80 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M81 XIN NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M82 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M83 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M84 NET_92 NET_82 VDD VDD P33 l=0.300u w=5.000u
M85 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M86 NET_92 NET_82 VDD VDD P33 l=0.300u w=5.000u
M87 VDD NET_82 NET_92 VDD P33 l=0.300u w=5.000u
M88 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M89 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M90 VSS NET_82 NET_7127 VDD33 P33 l=0.300u w=5.000u
M91 VSS NET_82 NET_7127 VDD33 P33 l=0.300u w=5.000u
M92 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M93 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M94 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M95 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M96 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M97 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M98 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M99 VDD33 VSS NET_7117 VDD33 P33 l=0.300u w=5.000u
M100 VDD33 VSS NET_7109 VDD33 P33 l=0.300u w=5.000u
M101 NET_7127 NET_81 NET_82 VDD33 P33 l=0.300u w=5.000u
M102 NET_7127 NET_81 NET_82 VDD33 P33 l=0.300u w=5.000u
M103 NET_7127 NET_81 NET_82 VDD33 P33 l=0.300u w=5.000u
M104 NET_7127 NET_81 VDD33 VDD33 P33 l=0.300u w=5.000u
M105 VDD33 NET_81 NET_7127 VDD33 P33 l=0.300u w=5.000u
M106 NET_7127 NET_81 VDD33 VDD33 P33 l=0.300u w=5.000u
M107 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M108 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M109 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M110 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M111 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M112 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M113 XOUT NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M114 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M115 VDD33 NET_7117 XOUT VDD33 P33 l=0.300u w=30.000u
M116 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M117 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M118 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M119 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M120 NET_60 NET_57 VDD33 VDD33 P33 l=0.300u w=5.000u
M121 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M122 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_57 NET_60 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M125 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M126 XOUT NET_60 VDD33 VDD33 P33 l=0.300u w=30.000u
M127 VDD33 NET_38 XOUT VDD33 P33 l=0.300u w=30.000u
M128 VDD33 NET_60 XOUT VDD33 P33 l=0.300u w=30.000u
M129 XOUT NET_60 VDD33 VDD33 P33 l=0.300u w=30.000u
M130 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M131 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M132 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M133 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M134 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M135 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M136 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M137 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M138 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M139 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M140 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M141 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M142 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M143 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M144 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M145 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M146 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M147 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M148 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M149 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M150 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M151 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
M152 VDD33 NET_7109 XIN VDD33 P33 l=0.300u w=30.000u
M153 XIN NET_7109 VDD33 VDD33 P33 l=0.300u w=30.000u
R1 XOUT NET_81 300.135
R2 XIN NET_38 300.135
.ends PXWE1

.subckt PX3   XOUT XC XIN FP
M1 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M2 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M3 XC NET_15 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M5 XC NET_15 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M7 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M8 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M9 XC NET_15 VDD VDD P18 l=0.180u w=5.000u
M10 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M11 XC NET_15 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M13 XC NET_15 VDD VDD P18 l=0.180u w=5.000u
M14 NET_62 NET_58 NET_60 VSS N33 l=0.350u w=8.000u
M15 NET_62 NET_58 VSS VSS N33 l=0.350u w=8.000u
M16 NET_62 NET_60 VDD33 VSS N33 l=0.350u w=4.500u
M17 VSS NET_60 NET_15 VSS N33 l=0.350u w=2.000u
M18 VSS NET_60 NET_15 VSS N33 l=0.350u w=2.000u
M19 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M20 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M21 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M22 VSSD NET_51 XOUT VSSD N33 l=0.400u w=28.000u
M23 VSSD NET_51 XOUT VSSD N33 l=0.400u w=28.000u
M24 XOUT NET_51 VSSD VSSD N33 l=0.400u w=28.000u
M25 VSSD NET_51 XOUT VSSD N33 l=0.400u w=28.000u
M26 XOUT NET_51 VSSD VSSD N33 l=0.400u w=28.000u
M27 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M28 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M29 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M30 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M31 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M32 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M33 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M34 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M35 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M36 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M38 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M39 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M40 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M42 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M43 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M44 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M46 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M48 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M50 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_50 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M52 NET_35 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M53 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M54 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M55 NET_15 NET_60 VDD VDD P33 l=0.300u w=5.000u
M56 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M57 NET_15 NET_60 VDD VDD P33 l=0.300u w=5.000u
M58 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M59 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M60 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M61 VSS NET_60 NET_7150 VDD33 P33 l=0.300u w=5.000u
M62 VSS NET_60 NET_7150 VDD33 P33 l=0.300u w=5.000u
M63 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M64 XOUT NET_51 VDD33 VDD33 P33 l=0.300u w=30.000u
M65 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M66 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M67 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M68 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M69 NET_7150 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M70 NET_7150 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M71 NET_60 NET_58 NET_7150 VDD33 P33 l=0.300u w=5.000u
M72 NET_7150 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M73 VDD33 NET_58 NET_7150 VDD33 P33 l=0.300u w=5.000u
M74 NET_7150 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M75 VDD33 VSS NET_7140 VDD33 P33 l=0.300u w=5.000u
M76 VDD33 VSS NET_7117 VDD33 P33 l=0.300u w=5.000u
M77 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M78 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M79 XOUT NET_51 VDD33 VDD33 P33 l=0.300u w=30.000u
M80 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M81 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M82 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M83 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M84 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M85 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M86 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M87 XOUT NET_51 VDD33 VDD33 P33 l=0.300u w=30.000u
M88 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M89 XOUT NET_51 VDD33 VDD33 P33 l=0.300u w=30.000u
M90 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M91 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M92 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M93 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M94 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M95 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M96 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M97 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M98 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M99 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M100 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M101 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M102 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M103 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M104 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M105 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M106 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M107 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M108 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M109 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M110 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M111 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M112 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M113 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M114 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M115 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M116 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
R1 XIN NET_51 300.135
R2 NET_58 XOUT 300.135
.ends PX3

.subckt PX2   XOUT XC XIN FP
M1 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M2 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M3 XC NET_15 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M5 XC NET_15 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M7 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M8 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M9 XC NET_15 VDD VDD P18 l=0.180u w=5.000u
M10 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M11 XC NET_15 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M13 XC NET_15 VDD VDD P18 l=0.180u w=5.000u
M14 NET_62 NET_58 NET_60 VSS N33 l=0.350u w=8.000u
M15 NET_62 NET_58 VSS VSS N33 l=0.350u w=8.000u
M16 NET_62 NET_60 VDD33 VSS N33 l=0.350u w=4.500u
M17 VSS NET_60 NET_15 VSS N33 l=0.350u w=2.000u
M18 VSS NET_60 NET_15 VSS N33 l=0.350u w=2.000u
M19 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M20 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M21 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M22 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M23 VSSD NET_51 XOUT VSSD N33 l=0.400u w=28.000u
M24 XOUT NET_51 VSSD VSSD N33 l=0.400u w=28.000u
M25 VSSD NET_51 XOUT VSSD N33 l=0.400u w=28.000u
M26 XOUT NET_51 VSSD VSSD N33 l=0.400u w=28.000u
M27 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M28 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M29 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M30 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M31 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M32 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M33 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M34 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M35 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M36 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M38 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M39 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M40 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M42 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M43 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M44 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M46 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M48 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M50 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_50 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M52 NET_35 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M53 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M54 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M55 NET_15 NET_60 VDD VDD P33 l=0.300u w=5.000u
M56 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M57 NET_15 NET_60 VDD VDD P33 l=0.300u w=5.000u
M58 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M59 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M60 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M61 VSS NET_60 NET_7150 VDD33 P33 l=0.300u w=5.000u
M62 VSS NET_60 NET_7150 VDD33 P33 l=0.300u w=5.000u
M63 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M64 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M65 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M66 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M67 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M68 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M69 NET_7150 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M70 NET_7150 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M71 NET_60 NET_58 NET_7150 VDD33 P33 l=0.300u w=5.000u
M72 NET_7150 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M73 VDD33 NET_58 NET_7150 VDD33 P33 l=0.300u w=5.000u
M74 NET_7150 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M75 VDD33 VSS NET_7140 VDD33 P33 l=0.300u w=5.000u
M76 VDD33 VSS NET_7117 VDD33 P33 l=0.300u w=5.000u
M77 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M78 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M79 XOUT NET_51 VDD33 VDD33 P33 l=0.300u w=30.000u
M80 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M81 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M82 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M83 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M84 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M85 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M86 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M87 XOUT NET_51 VDD33 VDD33 P33 l=0.300u w=30.000u
M88 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M89 XOUT NET_51 VDD33 VDD33 P33 l=0.300u w=30.000u
M90 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M91 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M92 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M93 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M94 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M95 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M96 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M97 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M98 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M99 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M100 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M101 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M102 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M103 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M104 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M105 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M106 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M107 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M108 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M109 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M110 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M111 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M112 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M113 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M114 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M115 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M116 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
R1 XIN NET_51 300.135
R2 NET_58 XOUT 300.135
.ends PX2

.subckt PX1   XOUT XC XIN FP
M1 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M2 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M3 XC NET_15 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M5 XC NET_15 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_15 XC VSS N18 l=0.180u w=2.000u
M7 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M8 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M9 XC NET_15 VDD VDD P18 l=0.180u w=5.000u
M10 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M11 XC NET_15 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_15 XC VDD P18 l=0.180u w=5.000u
M13 XC NET_15 VDD VDD P18 l=0.180u w=5.000u
M14 NET_62 NET_58 NET_60 VSS N33 l=0.350u w=8.000u
M15 NET_62 NET_58 VSS VSS N33 l=0.350u w=8.000u
M16 NET_62 NET_60 VDD33 VSS N33 l=0.350u w=4.500u
M17 VSS NET_60 NET_15 VSS N33 l=0.350u w=2.000u
M18 VSS NET_60 NET_15 VSS N33 l=0.350u w=2.000u
M19 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M20 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M21 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M22 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M23 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M24 XOUT NET_51 VSSD VSSD N33 l=0.400u w=28.000u
M25 VSSD NET_51 XOUT VSSD N33 l=0.400u w=28.000u
M26 XOUT NET_51 VSSD VSSD N33 l=0.400u w=28.000u
M27 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M28 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M29 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M30 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M31 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M32 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M33 VSSD NET_50 XOUT VSSD N33 l=0.400u w=28.000u
M34 XOUT NET_50 VSSD VSSD N33 l=0.400u w=28.000u
M35 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M36 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M38 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M39 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M40 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M42 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M43 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M44 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M46 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M48 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_35 XIN VSSD N33 l=0.400u w=28.000u
M50 XIN NET_35 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_50 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M52 NET_35 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M53 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M54 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M55 NET_15 NET_60 VDD VDD P33 l=0.300u w=5.000u
M56 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M57 NET_15 NET_60 VDD VDD P33 l=0.300u w=5.000u
M58 VDD NET_60 NET_15 VDD P33 l=0.300u w=5.000u
M59 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M60 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M61 VSS NET_60 NET_7150 VDD33 P33 l=0.300u w=5.000u
M62 VSS NET_60 NET_7150 VDD33 P33 l=0.300u w=5.000u
M63 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M64 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M65 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M66 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M67 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M68 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M69 NET_7150 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M70 NET_7150 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M71 NET_60 NET_58 NET_7150 VDD33 P33 l=0.300u w=5.000u
M72 NET_7150 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M73 VDD33 NET_58 NET_7150 VDD33 P33 l=0.300u w=5.000u
M74 NET_7150 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M75 VDD33 VSS NET_7140 VDD33 P33 l=0.300u w=5.000u
M76 VDD33 VSS NET_7117 VDD33 P33 l=0.300u w=5.000u
M77 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M78 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M79 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M80 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M81 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M82 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M83 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M84 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M85 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M86 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M87 XOUT NET_51 VDD33 VDD33 P33 l=0.300u w=30.000u
M88 VDD33 NET_51 XOUT VDD33 P33 l=0.300u w=30.000u
M89 XOUT NET_51 VDD33 VDD33 P33 l=0.300u w=30.000u
M90 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M91 VDD33 NET_7140 XOUT VDD33 P33 l=0.300u w=30.000u
M92 XOUT NET_7140 VDD33 VDD33 P33 l=0.300u w=30.000u
M93 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M94 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M95 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M96 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M97 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M98 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M99 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M100 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M101 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M102 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M103 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M104 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M105 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M106 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M107 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M108 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M109 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M110 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M111 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M112 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M113 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M114 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
M115 VDD33 NET_7117 XIN VDD33 P33 l=0.300u w=30.000u
M116 XIN NET_7117 VDD33 VDD33 P33 l=0.300u w=30.000u
R1 XIN NET_51 300.135
R2 NET_58 XOUT 300.135
.ends PX1

.subckt PANA2AP1  PAD
M1 NET_54 NET_50 SAVSS SAVSS N33 l=0.350u w=2.500u
M2 NET_54 NET_50 SAVSS SAVSS N33 l=0.350u w=2.500u
M3 SAVSS NET_50 NET_54 SAVSS N33 l=0.350u w=2.500u
M4 NET_54 NET_50 SAVSS SAVSS N33 l=0.350u w=2.500u
M5 SAVSS NET_48 NET_50 SAVSS N33 l=0.350u w=2.500u
M6 NET_50 NET_48 SAVSS SAVSS N33 l=0.350u w=2.500u
M7 SAVSS NET_48 NET_50 SAVSS N33 l=0.350u w=2.500u
M8 NET_50 NET_48 SAVSS SAVSS N33 l=0.350u w=2.500u
M9 SAVSS NET_5198 NET_48 SAVSS N33 l=0.350u w=2.500u
M10 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=35.000u
M11 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=35.000u
M12 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=35.000u
M13 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=35.000u
M14 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=35.000u
M15 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=35.000u
M16 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=35.000u
M17 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=35.000u
M18 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=35.000u
M19 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=35.000u
M20 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=35.000u
M21 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=35.000u
M22 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=35.000u
M23 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=35.000u
M24 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=35.000u
M25 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=35.000u
M26 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M27 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M28 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M29 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M30 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M31 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M32 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M33 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M34 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M35 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M36 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M37 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M38 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M39 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M40 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M41 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M42 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M43 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M44 SAVSSD NET_54 SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M45 SAVDD33 NET_54 SAVSSD SAVSSD N33 l=0.350u w=28.000u
M46 NET_54 NET_50 SAVDD33 SAVDD33 P33 l=0.350u w=2.500u
M47 NET_54 NET_50 SAVDD33 SAVDD33 P33 l=0.350u w=2.500u
M48 SAVDD33 NET_50 NET_54 SAVDD33 P33 l=0.350u w=2.500u
M49 NET_54 NET_50 SAVDD33 SAVDD33 P33 l=0.350u w=2.500u
M50 SAVDD33 NET_48 NET_50 SAVDD33 P33 l=0.350u w=2.500u
M51 NET_50 NET_48 SAVDD33 SAVDD33 P33 l=0.350u w=2.500u
M52 SAVDD33 NET_5198 NET_48 SAVDD33 P33 l=0.350u w=2.500u
M53 NET_48 NET_5198 SAVDD33 SAVDD33 P33 l=0.350u w=2.500u
M54 SAVDD33 NET_5198 NET_48 SAVDD33 P33 l=0.350u w=2.500u
M55 NET_7502 SAVSS NET_5198 SAVDD33 P33 l=7.120u w=0.300u
M56 NET_7502 SAVSS NET_7501 SAVDD33 P33 l=7.120u w=0.300u
M57 SAVDD33 SAVSS NET_7501 SAVDD33 P33 l=7.120u w=0.300u
M58 SAVSS NET_5198 SAVSS SAVSS C2 l=4.960u w=19.941u
M59 SAVSS NET_5198 SAVSS SAVSS C2 l=4.960u w=19.941u
DD1 SAVSSD PAD NDIO33 area=306.710p pj=78.488u
DD2 PAD SAVDD33 PDIO33 area=128.999p pj=63.094u
.ends PANA2AP1

.subckt PANA1AP1   PAD
M1 PAD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M2 PAD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M3 SAVSSD SAVSSD PAD SAVSSD N33 l=0.350u w=28.000u
M4 PAD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M5 SAVSSD SAVSSD PAD SAVSSD N33 l=0.350u w=28.000u
M6 PAD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M7 SAVSSD SAVSSD PAD SAVSSD N33 l=0.350u w=28.000u
M8 PAD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M9 PAD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M10 PAD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M11 SAVSSD SAVSSD PAD SAVSSD N33 l=0.350u w=28.000u
M12 PAD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M13 SAVSSD SAVSSD PAD SAVSSD N33 l=0.350u w=28.000u
M14 PAD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M15 SAVSSD SAVSSD PAD SAVSSD N33 l=0.350u w=28.000u
M16 PAD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M17 PAD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M18 PAD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M19 SAVDD33 SAVDD33 PAD SAVDD33 P33 l=0.300u w=30.000u
M20 PAD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M21 SAVDD33 SAVDD33 PAD SAVDD33 P33 l=0.300u w=30.000u
M22 PAD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M23 SAVDD33 SAVDD33 PAD SAVDD33 P33 l=0.300u w=30.000u
M24 PAD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M25 PAD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M26 PAD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M27 SAVDD33 SAVDD33 PAD SAVDD33 P33 l=0.300u w=30.000u
M28 PAD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M29 SAVDD33 SAVDD33 PAD SAVDD33 P33 l=0.300u w=30.000u
M30 PAD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M31 SAVDD33 SAVDD33 PAD SAVDD33 P33 l=0.300u w=30.000u
M32 PAD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
.ends PANA1AP1

.subckt PANA1AP  PAD
M1 PAD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M2 PAD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M3 SAVSS SAVSS PAD SAVSS N33 l=0.350u w=28.000u
M4 PAD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M5 SAVSS SAVSS PAD SAVSS N33 l=0.350u w=28.000u
M6 PAD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M7 SAVSS SAVSS PAD SAVSS N33 l=0.350u w=28.000u
M8 PAD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M9 PAD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M10 PAD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M11 SAVSS SAVSS PAD SAVSS N33 l=0.350u w=28.000u
M12 PAD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M13 SAVSS SAVSS PAD SAVSS N33 l=0.350u w=28.000u
M14 PAD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M15 SAVSS SAVSS PAD SAVSS N33 l=0.350u w=28.000u
M16 PAD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M17 PAD SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M18 PAD SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M19 SAVDD SAVDD PAD SAVDD P33 l=0.300u w=30.000u
M20 PAD SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M21 SAVDD SAVDD PAD SAVDD P33 l=0.300u w=30.000u
M22 PAD SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M23 SAVDD SAVDD PAD SAVDD P33 l=0.300u w=30.000u
M24 PAD SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M25 PAD SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M26 PAD SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M27 SAVDD SAVDD PAD SAVDD P33 l=0.300u w=30.000u
M28 PAD SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M29 SAVDD SAVDD PAD SAVDD P33 l=0.300u w=30.000u
M30 PAD SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M31 SAVDD SAVDD PAD SAVDD P33 l=0.300u w=30.000u
M32 PAD SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
.ends PANA1AP

.subckt PCI6BS   PAD OEN I C FP
M1 VSS NET_112 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_112 C VSS N18 l=0.180u w=2.000u
M3 C NET_112 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_112 C VSS N18 l=0.180u w=2.000u
M5 C NET_112 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_112 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_118 NET_112 VSS N18 l=0.180u w=2.000u
M8 VSS NET_118 NET_112 VSS N18 l=0.180u w=2.000u
M9 NET_112 NET_118 VSS VSS N18 l=0.180u w=2.000u
M10 VSS NET_118 NET_112 VSS N18 l=0.180u w=2.000u
M11 VSS NET_79 NET_75 VSS N18 l=0.180u w=4.000u
M12 VSS NET_79 NET_75 VSS N18 l=0.180u w=4.000u
M13 NET_80 I VSS VSS N18 l=0.180u w=4.000u
M14 NET_80 NET_81 NET_79 VSS N18 l=0.180u w=4.000u
M15 VSS OEN NET_81 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_81 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_84 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_84 VSS N18 l=0.180u w=2.000u
M19 NET_84 I VSS VSS N18 l=0.180u w=2.000u
M20 VSS I NET_84 VSS N18 l=0.180u w=2.000u
M21 NET_89 NET_84 VSS VSS N18 l=0.180u w=2.000u
M22 NET_89 NET_84 VSS VSS N18 l=0.180u w=2.000u
M23 VDD NET_112 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_118 NET_112 VDD P18 l=0.180u w=5.000u
M25 VDD NET_118 NET_112 VDD P18 l=0.180u w=5.000u
M26 VDD NET_112 C VDD P18 l=0.180u w=5.000u
M27 C NET_112 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_112 C VDD P18 l=0.180u w=5.000u
M29 C NET_112 VDD VDD P18 l=0.180u w=5.000u
M30 VDD NET_112 C VDD P18 l=0.180u w=5.000u
M31 VDD NET_84 NET_89 VDD P18 l=0.180u w=5.000u
M32 VDD NET_84 NET_89 VDD P18 l=0.180u w=5.000u
M33 VDD OEN NET_81 VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_81 VDD P18 l=0.180u w=5.000u
M35 NET_5976 OEN NET_84 VDD P18 l=0.180u w=5.000u
M36 NET_5976 I VDD VDD P18 l=0.180u w=5.000u
M37 NET_89 NET_84 VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_84 NET_89 VDD P18 l=0.180u w=5.000u
M39 VDD NET_79 NET_75 VDD P18 l=0.180u w=5.000u
M40 VDD NET_79 NET_75 VDD P18 l=0.180u w=5.000u
M41 NET_79 I VDD VDD P18 l=0.180u w=5.000u
M42 NET_79 I VDD VDD P18 l=0.180u w=5.000u
M43 VDD NET_81 NET_79 VDD P18 l=0.180u w=5.000u
M44 NET_79 NET_81 VDD VDD P18 l=0.180u w=5.000u
M45 NET_46 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M46 NET_46 FP PAD VSSD N33 l=0.400u w=28.000u
M47 PAD FP NET_36 VSSD N33 l=0.400u w=28.000u
M48 VSSD NET_49 NET_36 VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_51 NET_34 VSSD N33 l=0.400u w=28.000u
M50 NET_34 FP PAD VSSD N33 l=0.400u w=28.000u
M51 PAD FP NET_32 VSSD N33 l=0.400u w=28.000u
M52 NET_32 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M53 NET_48 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_48 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_43 VSSD N33 l=0.400u w=28.000u
M56 VSSD NET_49 NET_43 VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_51 NET_41 VSSD N33 l=0.400u w=28.000u
M58 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_39 VSSD N33 l=0.400u w=28.000u
M60 NET_39 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_29 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M62 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M64 NET_17 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M65 VSSD NET_26 NET_15 VSSD N33 l=0.400u w=28.000u
M66 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M67 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M68 NET_13 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M69 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_23 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M72 VSSD NET_26 NET_21 VSSD N33 l=0.400u w=28.000u
M73 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M74 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M75 NET_19 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M76 VSSD NET_29 NET_30 VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_29 NET_37 VSSD N33 l=0.400u w=28.000u
M78 NET_93 NET_100 NET_91 VSS N33 l=0.350u w=8.000u
M79 NET_93 NET_100 VSS VSS N33 l=0.350u w=8.000u
M80 NET_53 VDD33 NET_100 VSS N33 l=0.350u w=8.000u
M81 NET_53 VDD33 NET_100 VSS N33 l=0.350u w=8.000u
M82 NET_100 VDD33 NET_53 VSS N33 l=0.350u w=8.000u
M83 NET_93 NET_91 VDD33 VSS N33 l=0.350u w=0.820u
M84 VSS NET_91 NET_118 VSS N33 l=0.350u w=2.000u
M85 NET_96 NET_89 VSS VSS N33 l=0.350u w=8.000u
M86 VSS NET_10 NET_51 VSS N33 l=0.350u w=8.000u
M87 VSS NET_10 NET_51 VSS N33 l=0.350u w=8.000u
M88 VSS NET_57 NET_54 VSS N33 l=0.350u w=8.000u
M89 VSS NET_57 NET_54 VSS N33 l=0.350u w=8.000u
M90 VSS NET_79 NET_57 VSS N33 l=0.350u w=5.330u
M91 VSS NET_79 NET_57 VSS N33 l=0.350u w=5.330u
M92 NET_57 NET_79 VSS VSS N33 l=0.350u w=5.330u
M93 VSS NET_75 NET_58 VSS N33 l=0.350u w=5.330u
M94 NET_58 NET_75 VSS VSS N33 l=0.350u w=5.330u
M95 VSS NET_75 NET_58 VSS N33 l=0.350u w=5.330u
M96 NET_68 OEN VSS VSS N33 l=0.350u w=7.440u
M97 NET_68 OEN VSS VSS N33 l=0.350u w=7.440u
M98 VSS NET_81 NET_66 VSS N33 l=0.350u w=7.440u
M99 NET_66 NET_81 VSS VSS N33 l=0.350u w=7.440u
M100 NET_69 NET_3408 NET_71 VSS N33 l=0.350u w=8.000u
M101 NET_71 NET_68 VSS VSS N33 l=0.350u w=8.000u
M102 NET_96 NET_89 VSS VSS N33 l=0.350u w=8.000u
M103 VSS NET_84 NET_10 VSS N33 l=0.350u w=8.000u
M104 VSS NET_84 NET_10 VSS N33 l=0.350u w=8.000u
M105 NET_5957 NET_3408 VDD33 NET_1285 P33 l=0.300u w=30.000u
M106 NET_5957 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M107 NET_5959 NET_3408 VDD33 NET_1285 P33 l=0.300u w=30.000u
M108 NET_5959 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M109 NET_1285 NET_1285 NET_1285 NET_1285 P33 l=1.070u w=5.000u
M110 VSS NET_91 NET_3449 VDD33 P33 l=0.300u w=5.100u
M111 VSS NET_91 NET_3449 VDD33 P33 l=0.300u w=5.100u
M112 VDD NET_91 NET_118 VDD P33 l=0.300u w=5.000u
M113 NET_5954 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M114 NET_5954 NET_3408 VDD33 NET_1285 P33 l=0.300u w=30.000u
M115 VDD33 NET_6035 NET_5947 NET_1285 P33 l=0.300u w=30.000u
M116 NET_5947 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M117 NET_5955 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M118 NET_5955 NET_3408 VDD33 NET_1285 P33 l=0.300u w=30.000u
M119 VDD33 NET_6035 NET_5952 NET_1285 P33 l=0.300u w=30.000u
M120 NET_5952 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M121 NET_91 NET_100 NET_3449 VDD33 P33 l=0.300u w=5.000u
M122 NET_91 NET_100 NET_3449 VDD33 P33 l=0.300u w=5.000u
M123 NET_3449 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 NET_3449 NET_91 VSS VDD33 P33 l=0.300u w=5.100u
M125 VDD NET_91 NET_118 VDD P33 l=0.300u w=5.000u
M126 VDD NET_91 NET_118 VDD P33 l=0.300u w=5.000u
M127 NET_118 NET_91 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_91 NET_118 VDD P33 l=0.300u w=5.000u
M129 NET_5945 NET_6035 VDD33 NET_1285 P33 l=0.300u w=30.000u
M130 NET_5950 NET_6035 VDD33 NET_1285 P33 l=0.300u w=30.000u
M131 VDD33 NET_6034 NET_5942 NET_1285 P33 l=0.300u w=30.000u
M132 NET_5942 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M133 PAD NET_69 NET_5938 NET_1285 P33 l=0.300u w=30.000u
M134 NET_5938 NET_6034 VDD33 NET_1285 P33 l=0.300u w=30.000u
M135 VDD33 NET_6034 NET_5943 NET_1285 P33 l=0.300u w=30.000u
M136 NET_5943 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M137 PAD NET_69 NET_5941 NET_1285 P33 l=0.300u w=30.000u
M138 NET_5941 NET_6034 VDD33 NET_1285 P33 l=0.300u w=30.000u
M139 VDD33 NET_10 NET_51 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_10 NET_51 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_6038 NET_5936 NET_1285 P33 l=0.300u w=30.000u
M142 NET_5936 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M143 VDD33 NET_6038 NET_5939 NET_1285 P33 l=0.300u w=30.000u
M144 NET_5939 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M145 NET_51 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M146 NET_5926 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M147 NET_5926 NET_6038 VDD33 NET_1285 P33 l=0.300u w=30.000u
M148 NET_5931 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M149 NET_5931 NET_6038 VDD33 NET_1285 P33 l=0.300u w=30.000u
M150 VDD33 VSS NET_3408 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_10 NET_96 VDD33 P33 l=0.300u w=5.000u
M152 NET_10 NET_96 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 NET_5924 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M154 PAD NET_69 NET_5922 NET_1285 P33 l=0.300u w=30.000u
M155 NET_5922 NET_6039 VDD33 NET_1285 P33 l=0.300u w=30.000u
M156 NET_5929 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M157 PAD NET_69 NET_5927 NET_1285 P33 l=0.300u w=30.000u
M158 NET_5927 NET_6039 VDD33 NET_1285 P33 l=0.300u w=30.000u
M159 VDD33 NET_68 NET_66 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_66 NET_68 VDD33 P33 l=0.300u w=5.000u
M161 NET_5911 NET_54 VDD33 NET_1285 P33 l=0.300u w=30.000u
M162 NET_5911 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M163 NET_5915 NET_54 VDD33 NET_1285 P33 l=0.300u w=30.000u
M164 NET_5915 NET_69 PAD NET_1285 P33 l=0.300u w=30.000u
M165 PAD NET_69 NET_5909 NET_1285 P33 l=0.300u w=30.000u
M166 NET_5909 NET_54 VDD33 NET_1285 P33 l=0.300u w=30.000u
M167 PAD NET_69 NET_5913 NET_1285 P33 l=0.300u w=30.000u
M168 NET_5913 NET_54 VDD33 NET_1285 P33 l=0.300u w=30.000u
M169 NET_1285 PAD VDD33 NET_1285 P33 l=0.350u w=5.000u
M170 NET_1285 PAD VDD33 NET_1285 P33 l=0.350u w=5.000u
M171 VDD33 PAD NET_1285 NET_1285 P33 l=0.350u w=5.000u
M172 VDD33 NET_57 NET_54 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_57 NET_54 VDD33 P33 l=0.300u w=5.000u
M174 NET_54 NET_57 VDD33 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_57 NET_54 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_57 NET_58 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_58 NET_57 VDD33 P33 l=0.300u w=5.000u
M178 PAD NET_69 NET_5945 NET_1285 P33 l=0.300u w=30.000u
M179 PAD NET_69 NET_5950 NET_1285 P33 l=0.300u w=30.000u
M180 VDD33 NET_53 NET_3449 VDD33 P33 l=0.300u w=5.000u
M181 NET_3449 NET_91 VSS VDD33 P33 l=0.300u w=5.100u
M182 VDD33 NET_6039 NET_5924 NET_1285 P33 l=0.300u w=30.000u
M183 VDD33 NET_6039 NET_5929 NET_1285 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_69 NET_1285 P33 l=0.350u w=10.000u
M185 PAD VDD33 NET_1285 NET_1285 P33 l=0.350u w=15.000u
R1 PAD NET_53 300.135
R2 NET_49 NET_25 1412.95
R3 NET_51 NET_49 1412.95
R4 NET_24 NET_25 1412.95
R5 NET_26 NET_24 1412.95
R6 NET_54 NET_6039 496.265
R7 NET_6038 NET_6034 496.265
R8 NET_6034 NET_6035 496.265
R9 NET_6039 NET_6038 496.265
.ends PCI6BS

.subckt PCI6B   PAD OEN I C FP
M1 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M3 C NET_111 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M5 C NET_111 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_114 NET_111 VSS N18 l=0.180u w=2.000u
M8 VSS NET_114 NET_111 VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_57 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_57 VSS N18 l=0.180u w=2.000u
M11 NET_57 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_57 VSS N18 l=0.180u w=2.000u
M13 VSS NET_82 NET_78 VSS N18 l=0.180u w=4.000u
M14 VSS NET_82 NET_78 VSS N18 l=0.180u w=4.000u
M15 NET_83 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_83 NET_84 NET_82 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_84 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_84 VSS N18 l=0.180u w=2.000u
M19 NET_87 NET_57 VSS VSS N18 l=0.180u w=2.000u
M20 NET_87 NET_57 VSS VSS N18 l=0.180u w=2.000u
M21 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_114 NET_111 VDD P18 l=0.180u w=5.000u
M23 VDD NET_114 NET_111 VDD P18 l=0.180u w=5.000u
M24 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M25 C NET_111 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M27 C NET_111 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_57 NET_87 VDD P18 l=0.180u w=5.000u
M30 VDD NET_57 NET_87 VDD P18 l=0.180u w=5.000u
M31 NET_6079 OEN NET_57 VDD P18 l=0.180u w=5.000u
M32 NET_6079 I VDD VDD P18 l=0.180u w=5.000u
M33 VDD OEN NET_84 VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_84 VDD P18 l=0.180u w=5.000u
M35 VDD NET_57 NET_87 VDD P18 l=0.180u w=5.000u
M36 VDD NET_57 NET_87 VDD P18 l=0.180u w=5.000u
M37 VDD NET_82 NET_78 VDD P18 l=0.180u w=5.000u
M38 VDD NET_82 NET_78 VDD P18 l=0.180u w=5.000u
M39 NET_82 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_82 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_84 NET_82 VDD P18 l=0.180u w=5.000u
M42 NET_82 NET_84 VDD VDD P18 l=0.180u w=5.000u
M43 NET_92 NET_87 VSS VSS N33 l=0.350u w=8.000u
M44 VSS NET_10 NET_51 VSS N33 l=0.350u w=8.000u
M45 VSS NET_10 NET_51 VSS N33 l=0.350u w=8.000u
M46 NET_56 NET_3405 NET_54 VSS N33 l=0.350u w=8.000u
M47 NET_56 NET_76 VSS VSS N33 l=0.350u w=8.000u
M48 VSS NET_65 NET_62 VSS N33 l=0.350u w=8.000u
M49 VSS NET_65 NET_62 VSS N33 l=0.350u w=8.000u
M50 VSS NET_82 NET_65 VSS N33 l=0.350u w=5.330u
M51 VSS NET_82 NET_65 VSS N33 l=0.350u w=5.330u
M52 NET_65 NET_82 VSS VSS N33 l=0.350u w=5.330u
M53 VSS NET_78 NET_66 VSS N33 l=0.350u w=5.330u
M54 NET_66 NET_78 VSS VSS N33 l=0.350u w=5.330u
M55 VSS NET_78 NET_66 VSS N33 l=0.350u w=5.330u
M56 NET_76 OEN VSS VSS N33 l=0.350u w=7.440u
M57 NET_76 OEN VSS VSS N33 l=0.350u w=7.440u
M58 VSS NET_84 NET_74 VSS N33 l=0.350u w=7.440u
M59 NET_74 NET_84 VSS VSS N33 l=0.350u w=7.440u
M60 NET_92 NET_87 VSS VSS N33 l=0.350u w=8.000u
M61 VSS NET_57 NET_10 VSS N33 l=0.350u w=8.000u
M62 VSS NET_57 NET_10 VSS N33 l=0.350u w=8.000u
M63 NET_53 VDD33 NET_96 VSS N33 l=0.350u w=8.000u
M64 NET_53 VDD33 NET_96 VSS N33 l=0.350u w=8.000u
M65 NET_96 VDD33 NET_53 VSS N33 l=0.350u w=8.000u
M66 NET_102 NET_96 VSS VSS N33 l=0.350u w=7.600u
M67 NET_102 NET_96 VSS VSS N33 l=0.350u w=7.600u
M68 VSS NET_102 NET_114 VSS N33 l=0.350u w=2.000u
M69 VSS NET_102 NET_114 VSS N33 l=0.350u w=2.000u
M70 NET_46 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_46 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M73 NET_36 NET_49 VSSD VSSD N33 l=0.400u w=28.000u
M74 VSSD NET_51 NET_34 VSSD N33 l=0.400u w=28.000u
M75 NET_34 FP PAD VSSD N33 l=0.400u w=28.000u
M76 PAD FP NET_32 VSSD N33 l=0.400u w=28.000u
M77 NET_32 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M78 NET_48 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_48 FP PAD VSSD N33 l=0.400u w=28.000u
M80 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M81 NET_43 NET_49 VSSD VSSD N33 l=0.400u w=28.000u
M82 VSSD NET_51 NET_41 VSSD N33 l=0.400u w=28.000u
M83 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M84 PAD FP NET_39 VSSD N33 l=0.400u w=28.000u
M85 NET_39 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M86 NET_29 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M87 VSSD NET_29 NET_30 VSSD N33 l=0.400u w=28.000u
M88 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M89 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M90 NET_17 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M91 VSSD NET_26 NET_15 VSSD N33 l=0.400u w=28.000u
M92 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M93 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M94 NET_13 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M95 VSSD NET_29 NET_37 VSSD N33 l=0.400u w=28.000u
M96 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M97 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M98 NET_23 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M99 VSSD NET_26 NET_21 VSSD N33 l=0.400u w=28.000u
M100 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M101 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M102 NET_19 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M103 VDD NET_102 NET_114 VDD P33 l=0.300u w=5.000u
M104 NET_6050 NET_3405 VDD33 NET_1282 P33 l=0.300u w=30.000u
M105 NET_6050 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M106 NET_6052 NET_3405 VDD33 NET_1282 P33 l=0.300u w=30.000u
M107 NET_6052 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M108 NET_1282 NET_1282 NET_1282 NET_1282 P33 l=1.070u w=5.000u
M109 VDD NET_102 NET_114 VDD P33 l=0.300u w=5.000u
M110 VDD NET_102 NET_114 VDD P33 l=0.300u w=5.000u
M111 NET_114 NET_102 VDD VDD P33 l=0.300u w=5.000u
M112 VDD NET_102 NET_114 VDD P33 l=0.300u w=5.000u
M113 NET_6043 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M114 NET_6043 NET_3405 VDD33 NET_1282 P33 l=0.300u w=30.000u
M115 VDD33 NET_6126 NET_6041 NET_1282 P33 l=0.300u w=30.000u
M116 NET_6041 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M117 NET_6048 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M118 NET_6048 NET_3405 VDD33 NET_1282 P33 l=0.300u w=30.000u
M119 VDD33 NET_6126 NET_6046 NET_1282 P33 l=0.300u w=30.000u
M120 NET_6046 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M121 NET_102 NET_96 NET_3440 VDD33 P33 l=0.300u w=5.000u
M122 NET_102 NET_96 NET_3440 VDD33 P33 l=0.300u w=5.000u
M123 NET_102 NET_96 NET_3440 VDD33 P33 l=0.300u w=5.000u
M124 NET_102 NET_96 NET_3440 VDD33 P33 l=0.300u w=5.000u
M125 NET_3440 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 VDD33 NET_53 NET_3440 VDD33 P33 l=0.300u w=5.000u
M127 NET_3440 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M128 NET_6039 NET_6126 VDD33 NET_1282 P33 l=0.300u w=30.000u
M129 NET_6044 NET_6126 VDD33 NET_1282 P33 l=0.300u w=30.000u
M130 NET_6033 NET_6125 VDD33 NET_1282 P33 l=0.300u w=30.000u
M131 NET_6033 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M132 PAD NET_54 NET_6031 NET_1282 P33 l=0.300u w=30.000u
M133 NET_6031 NET_6125 VDD33 NET_1282 P33 l=0.300u w=30.000u
M134 NET_6038 NET_6125 VDD33 NET_1282 P33 l=0.300u w=30.000u
M135 NET_6038 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M136 PAD NET_54 NET_6036 NET_1282 P33 l=0.300u w=30.000u
M137 NET_6036 NET_6125 VDD33 NET_1282 P33 l=0.300u w=30.000u
M138 VDD33 NET_10 NET_51 VDD33 P33 l=0.300u w=5.000u
M139 VDD33 NET_10 NET_51 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_6129 NET_6029 NET_1282 P33 l=0.300u w=30.000u
M141 NET_6029 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M142 VDD33 NET_6129 NET_6034 NET_1282 P33 l=0.300u w=30.000u
M143 NET_6034 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M144 NET_51 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M145 NET_6019 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M146 NET_6019 NET_6129 VDD33 NET_1282 P33 l=0.300u w=30.000u
M147 NET_6024 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M148 NET_6024 NET_6129 VDD33 NET_1282 P33 l=0.300u w=30.000u
M149 VDD33 VSS NET_3405 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_10 NET_92 VDD33 P33 l=0.300u w=5.000u
M151 NET_10 NET_92 VDD33 VDD33 P33 l=0.300u w=5.000u
M152 NET_6017 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M153 PAD NET_54 NET_6015 NET_1282 P33 l=0.300u w=30.000u
M154 NET_6015 NET_6130 VDD33 NET_1282 P33 l=0.300u w=30.000u
M155 NET_6022 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M156 PAD NET_54 NET_6020 NET_1282 P33 l=0.300u w=30.000u
M157 NET_6020 NET_6130 VDD33 NET_1282 P33 l=0.300u w=30.000u
M158 VDD33 NET_76 NET_74 VDD33 P33 l=0.300u w=5.000u
M159 VDD33 NET_74 NET_76 VDD33 P33 l=0.300u w=5.000u
M160 NET_6006 NET_62 VDD33 NET_1282 P33 l=0.300u w=30.000u
M161 NET_6006 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M162 NET_6010 NET_62 VDD33 NET_1282 P33 l=0.300u w=30.000u
M163 NET_6010 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M164 PAD NET_54 NET_6004 NET_1282 P33 l=0.300u w=30.000u
M165 NET_6004 NET_62 VDD33 NET_1282 P33 l=0.300u w=30.000u
M166 PAD NET_54 NET_6008 NET_1282 P33 l=0.300u w=30.000u
M167 NET_6008 NET_62 VDD33 NET_1282 P33 l=0.300u w=30.000u
M168 NET_1282 PAD VDD33 NET_1282 P33 l=0.350u w=5.000u
M169 NET_1282 PAD VDD33 NET_1282 P33 l=0.350u w=5.000u
M170 VDD33 PAD NET_1282 NET_1282 P33 l=0.350u w=5.000u
M171 VDD33 NET_65 NET_62 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_65 NET_62 VDD33 P33 l=0.300u w=5.000u
M173 NET_62 NET_65 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_65 NET_62 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_65 NET_66 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_66 NET_65 VDD33 P33 l=0.300u w=5.000u
M177 PAD NET_54 NET_6039 NET_1282 P33 l=0.300u w=30.000u
M178 PAD NET_54 NET_6044 NET_1282 P33 l=0.300u w=30.000u
M179 VDD33 NET_53 NET_3440 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_6130 NET_6017 NET_1282 P33 l=0.300u w=30.000u
M181 VDD33 NET_6130 NET_6022 NET_1282 P33 l=0.300u w=30.000u
M182 PAD VDD33 NET_54 NET_1282 P33 l=0.350u w=10.000u
M183 PAD VDD33 NET_1282 NET_1282 P33 l=0.350u w=15.000u
R1 PAD NET_53 300.135
R2 NET_49 NET_25 1412.95
R3 NET_51 NET_49 1412.95
R4 NET_24 NET_25 1412.95
R5 NET_26 NET_24 1412.95
R6 NET_62 NET_6130 496.265
R7 NET_6129 NET_6125 496.265
R8 NET_6125 NET_6126 496.265
R9 NET_6129 NET_6130 496.265
.ends PCI6B

.subckt PCI3BS   PAD OEN I C FP
M1 VSS NET_117 NET_103 VSS N18 l=0.180u w=2.000u
M2 VSS NET_117 NET_103 VSS N18 l=0.180u w=2.000u
M3 NET_103 NET_117 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_117 NET_103 VSS N18 l=0.180u w=2.000u
M5 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M6 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M7 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M9 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M10 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M11 VSS NET_77 NET_73 VSS N18 l=0.180u w=4.000u
M12 VSS NET_77 NET_73 VSS N18 l=0.180u w=4.000u
M13 NET_78 I VSS VSS N18 l=0.180u w=4.000u
M14 NET_78 NET_79 NET_77 VSS N18 l=0.180u w=4.000u
M15 VSS OEN NET_79 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_79 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_82 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_82 VSS N18 l=0.180u w=2.000u
M19 NET_82 I VSS VSS N18 l=0.180u w=2.000u
M20 VSS I NET_82 VSS N18 l=0.180u w=2.000u
M21 NET_87 NET_82 VSS VSS N18 l=0.180u w=2.000u
M22 NET_87 NET_82 VSS VSS N18 l=0.180u w=2.000u
M23 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_117 NET_103 VDD P18 l=0.180u w=5.000u
M25 VDD NET_117 NET_103 VDD P18 l=0.180u w=5.000u
M26 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M27 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M29 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M30 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M31 VDD NET_82 NET_87 VDD P18 l=0.180u w=5.000u
M32 VDD NET_82 NET_87 VDD P18 l=0.180u w=5.000u
M33 VDD OEN NET_79 VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_79 VDD P18 l=0.180u w=5.000u
M35 NET_5852 OEN NET_82 VDD P18 l=0.180u w=5.000u
M36 NET_5852 I VDD VDD P18 l=0.180u w=5.000u
M37 NET_87 NET_82 VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_82 NET_87 VDD P18 l=0.180u w=5.000u
M39 VDD NET_77 NET_73 VDD P18 l=0.180u w=5.000u
M40 VDD NET_77 NET_73 VDD P18 l=0.180u w=5.000u
M41 NET_77 I VDD VDD P18 l=0.180u w=5.000u
M42 NET_77 I VDD VDD P18 l=0.180u w=5.000u
M43 VDD NET_79 NET_77 VDD P18 l=0.180u w=5.000u
M44 NET_77 NET_79 VDD VDD P18 l=0.180u w=5.000u
M45 NET_46 NET_27 VSSD VSSD N33 l=0.400u w=28.000u
M46 NET_46 FP PAD VSSD N33 l=0.400u w=28.000u
M47 PAD FP NET_36 VSSD N33 l=0.400u w=28.000u
M48 VSSD NET_49 NET_36 VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_51 NET_34 VSSD N33 l=0.400u w=28.000u
M50 NET_34 FP PAD VSSD N33 l=0.400u w=28.000u
M51 PAD FP NET_32 VSSD N33 l=0.400u w=28.000u
M52 NET_32 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M53 NET_48 NET_27 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_48 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_43 VSSD N33 l=0.400u w=28.000u
M56 VSSD NET_49 NET_43 VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_51 NET_41 VSSD N33 l=0.400u w=28.000u
M58 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_39 VSSD N33 l=0.400u w=28.000u
M60 NET_39 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_29 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M62 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M64 NET_17 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M65 VSSD NET_24 NET_15 VSSD N33 l=0.400u w=28.000u
M66 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M67 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M68 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M69 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_23 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M72 VSSD NET_24 NET_21 VSSD N33 l=0.400u w=28.000u
M73 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M74 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M75 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M76 VSSD NET_29 NET_30 VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_29 NET_37 VSSD N33 l=0.400u w=28.000u
M78 NET_53 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M79 NET_53 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M80 NET_90 VDD33 NET_53 VSS N33 l=0.350u w=8.000u
M81 NET_102 NET_90 NET_100 VSS N33 l=0.350u w=8.000u
M82 NET_102 NET_90 VSS VSS N33 l=0.350u w=8.000u
M83 NET_102 NET_100 VDD33 VSS N33 l=0.350u w=0.820u
M84 VSS NET_100 NET_117 VSS N33 l=0.350u w=2.000u
M85 NET_96 NET_87 VSS VSS N33 l=0.350u w=8.000u
M86 VSS NET_10 NET_51 VSS N33 l=0.350u w=8.000u
M87 VSS NET_10 NET_51 VSS N33 l=0.350u w=8.000u
M88 VSS NET_54 NET_70 VSS N33 l=0.350u w=4.000u
M89 VSS NET_54 NET_70 VSS N33 l=0.350u w=4.000u
M90 VSS NET_77 NET_54 VSS N33 l=0.350u w=5.330u
M91 VSS NET_77 NET_54 VSS N33 l=0.350u w=5.330u
M92 NET_54 NET_77 VSS VSS N33 l=0.350u w=5.330u
M93 VSS NET_73 NET_55 VSS N33 l=0.350u w=5.330u
M94 NET_55 NET_73 VSS VSS N33 l=0.350u w=5.330u
M95 VSS NET_73 NET_55 VSS N33 l=0.350u w=5.330u
M96 NET_65 OEN VSS VSS N33 l=0.350u w=7.440u
M97 NET_65 OEN VSS VSS N33 l=0.350u w=7.440u
M98 VSS NET_79 NET_63 VSS N33 l=0.350u w=7.440u
M99 NET_63 NET_79 VSS VSS N33 l=0.350u w=7.440u
M100 NET_66 NET_3422 NET_68 VSS N33 l=0.350u w=8.000u
M101 NET_68 NET_65 VSS VSS N33 l=0.350u w=8.000u
M102 NET_96 NET_87 VSS VSS N33 l=0.350u w=8.000u
M103 VSS NET_82 NET_10 VSS N33 l=0.350u w=8.000u
M104 VSS NET_82 NET_10 VSS N33 l=0.350u w=8.000u
M105 NET_5833 NET_3422 VDD33 NET_1285 P33 l=0.300u w=30.000u
M106 NET_5833 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M107 NET_5835 NET_3422 VDD33 NET_1285 P33 l=0.300u w=30.000u
M108 NET_5835 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M109 NET_1285 NET_1285 NET_1285 NET_1285 P33 l=1.070u w=5.000u
M110 VSS NET_100 NET_3447 VDD33 P33 l=0.300u w=5.100u
M111 VSS NET_100 NET_3447 VDD33 P33 l=0.300u w=5.100u
M112 VDD NET_100 NET_117 VDD P33 l=0.300u w=5.000u
M113 PAD NET_66 NET_5826 NET_1285 P33 l=0.300u w=30.000u
M114 NET_5826 NET_3422 VDD33 NET_1285 P33 l=0.300u w=30.000u
M115 VDD33 NET_5903 NET_5824 NET_1285 P33 l=0.300u w=30.000u
M116 NET_5824 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M117 PAD NET_66 NET_5831 NET_1285 P33 l=0.300u w=30.000u
M118 NET_5831 NET_3422 VDD33 NET_1285 P33 l=0.300u w=30.000u
M119 VDD33 NET_5903 NET_5829 NET_1285 P33 l=0.300u w=30.000u
M120 NET_5829 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M121 NET_3447 NET_100 VSS VDD33 P33 l=0.300u w=5.100u
M122 NET_100 NET_90 NET_3447 VDD33 P33 l=0.300u w=5.000u
M123 NET_100 NET_90 NET_3447 VDD33 P33 l=0.300u w=5.000u
M124 NET_3447 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 VDD NET_100 NET_117 VDD P33 l=0.300u w=5.000u
M126 VDD NET_100 NET_117 VDD P33 l=0.300u w=5.000u
M127 NET_117 NET_100 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_100 NET_117 VDD P33 l=0.300u w=5.000u
M129 PAD NET_66 NET_5822 NET_1285 P33 l=0.300u w=30.000u
M130 PAD NET_66 NET_5827 NET_1285 P33 l=0.300u w=30.000u
M131 NET_5820 NET_5904 VDD33 NET_1285 P33 l=0.300u w=30.000u
M132 NET_5820 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M133 PAD NET_66 NET_5812 NET_1285 P33 l=0.300u w=30.000u
M134 NET_5821 NET_5904 VDD33 NET_1285 P33 l=0.300u w=30.000u
M135 NET_5821 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M136 PAD NET_66 NET_5816 NET_1285 P33 l=0.300u w=30.000u
M137 VDD33 NET_10 NET_51 VDD33 P33 l=0.300u w=5.000u
M138 VDD33 NET_10 NET_51 VDD33 P33 l=0.300u w=5.000u
M139 NET_5822 NET_5903 VDD33 NET_1285 P33 l=0.300u w=30.000u
M140 NET_5827 NET_5903 VDD33 NET_1285 P33 l=0.300u w=30.000u
M141 VDD33 NET_5907 NET_5810 NET_1285 P33 l=0.300u w=30.000u
M142 NET_5810 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M143 VDD33 NET_5907 NET_5814 NET_1285 P33 l=0.300u w=30.000u
M144 NET_5814 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M145 NET_5802 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M146 NET_5802 NET_5907 VDD33 NET_1285 P33 l=0.300u w=30.000u
M147 NET_5807 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M148 NET_5807 NET_5907 VDD33 NET_1285 P33 l=0.300u w=30.000u
M149 VDD33 VSS NET_3422 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_10 NET_96 VDD33 P33 l=0.300u w=5.000u
M151 NET_10 NET_96 VDD33 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_5909 NET_5800 NET_1285 P33 l=0.300u w=30.000u
M153 NET_5800 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M154 PAD NET_66 NET_5798 NET_1285 P33 l=0.300u w=30.000u
M155 VDD33 NET_5909 NET_5805 NET_1285 P33 l=0.300u w=30.000u
M156 NET_5805 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M157 PAD NET_66 NET_5803 NET_1285 P33 l=0.300u w=30.000u
M158 VDD33 NET_65 NET_63 VDD33 P33 l=0.300u w=5.000u
M159 VDD33 NET_63 NET_65 VDD33 P33 l=0.300u w=5.000u
M160 NET_5789 NET_70 VDD33 NET_1285 P33 l=0.300u w=30.000u
M161 NET_5793 NET_70 VDD33 NET_1285 P33 l=0.300u w=30.000u
M162 NET_5798 NET_5909 VDD33 NET_1285 P33 l=0.300u w=30.000u
M163 NET_5803 NET_5909 VDD33 NET_1285 P33 l=0.300u w=30.000u
M164 PAD NET_66 NET_5787 NET_1285 P33 l=0.300u w=30.000u
M165 NET_5787 NET_70 VDD33 NET_1285 P33 l=0.300u w=30.000u
M166 PAD NET_66 NET_5791 NET_1285 P33 l=0.300u w=30.000u
M167 NET_5791 NET_70 VDD33 NET_1285 P33 l=0.300u w=30.000u
M168 NET_1285 PAD VDD33 NET_1285 P33 l=0.350u w=5.000u
M169 NET_1285 PAD VDD33 NET_1285 P33 l=0.350u w=5.000u
M170 VDD33 PAD NET_1285 NET_1285 P33 l=0.350u w=5.000u
M171 VDD33 NET_54 NET_70 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_54 NET_70 VDD33 P33 l=0.300u w=5.000u
M173 NET_70 NET_54 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_54 NET_70 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_54 NET_55 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_55 NET_54 VDD33 P33 l=0.300u w=5.000u
M177 NET_3447 NET_100 VSS VDD33 P33 l=0.300u w=5.100u
M178 VDD33 NET_53 NET_3447 VDD33 P33 l=0.300u w=5.000u
M179 NET_5812 NET_5904 VDD33 NET_1285 P33 l=0.300u w=30.000u
M180 NET_5816 NET_5904 VDD33 NET_1285 P33 l=0.300u w=30.000u
M181 NET_5789 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M182 NET_5793 NET_66 PAD NET_1285 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_66 NET_1285 P33 l=0.350u w=10.000u
M184 PAD VDD33 NET_1285 NET_1285 P33 l=0.350u w=15.000u
R1 PAD NET_53 300.135
R2 NET_24 NET_25 1695.72
R3 NET_49 NET_27 1695.72
R4 NET_51 NET_49 1695.72
R5 NET_25 NET_27 1695.72
R6 NET_70 NET_5909 883.184
R7 NET_5907 NET_5904 883.184
R8 NET_5904 NET_5903 883.184
R9 NET_5909 NET_5907 883.184
.ends PCI3BS

.subckt PCI3B   PAD OEN I C FP
M1 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M3 C NET_111 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M5 C NET_111 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_114 NET_111 VSS N18 l=0.180u w=2.000u
M8 VSS NET_114 NET_111 VSS N18 l=0.180u w=2.000u
M9 VSS NET_61 NET_57 VSS N18 l=0.180u w=4.000u
M10 VSS NET_61 NET_57 VSS N18 l=0.180u w=4.000u
M11 NET_62 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_62 NET_79 NET_61 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_79 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_79 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_82 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_82 VSS N18 l=0.180u w=2.000u
M17 NET_82 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_82 VSS N18 l=0.180u w=2.000u
M19 NET_87 NET_82 VSS VSS N18 l=0.180u w=2.000u
M20 NET_87 NET_82 VSS VSS N18 l=0.180u w=2.000u
M21 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_114 NET_111 VDD P18 l=0.180u w=5.000u
M23 VDD NET_114 NET_111 VDD P18 l=0.180u w=5.000u
M24 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M25 C NET_111 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M27 C NET_111 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_82 NET_87 VDD P18 l=0.180u w=5.000u
M30 VDD NET_82 NET_87 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_79 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_79 VDD P18 l=0.180u w=5.000u
M33 NET_6048 OEN NET_82 VDD P18 l=0.180u w=5.000u
M34 NET_6048 I VDD VDD P18 l=0.180u w=5.000u
M35 VDD NET_82 NET_87 VDD P18 l=0.180u w=5.000u
M36 VDD NET_82 NET_87 VDD P18 l=0.180u w=5.000u
M37 VDD NET_61 NET_57 VDD P18 l=0.180u w=5.000u
M38 VDD NET_61 NET_57 VDD P18 l=0.180u w=5.000u
M39 NET_61 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_61 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_79 NET_61 VDD P18 l=0.180u w=5.000u
M42 NET_61 NET_79 VDD VDD P18 l=0.180u w=5.000u
M43 NET_46 NET_27 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_46 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_36 NET_49 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_51 NET_34 VSSD N33 l=0.400u w=28.000u
M48 NET_34 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_32 VSSD N33 l=0.400u w=28.000u
M50 NET_32 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_48 NET_27 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_48 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_43 NET_49 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_51 NET_41 VSSD N33 l=0.400u w=28.000u
M56 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_39 VSSD N33 l=0.400u w=28.000u
M58 NET_39 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_29 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M60 VSSD NET_29 NET_30 VSSD N33 l=0.400u w=28.000u
M61 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_17 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_24 NET_15 VSSD N33 l=0.400u w=28.000u
M65 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M67 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M68 VSSD NET_29 NET_37 VSSD N33 l=0.400u w=28.000u
M69 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_23 NET_29 VSSD VSSD N33 l=0.400u w=28.000u
M72 VSSD NET_24 NET_21 VSSD N33 l=0.400u w=28.000u
M73 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M74 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M75 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M76 NET_96 NET_87 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_10 NET_51 VSS N33 l=0.350u w=8.000u
M78 VSS NET_10 NET_51 VSS N33 l=0.350u w=8.000u
M79 VSS NET_66 NET_63 VSS N33 l=0.350u w=4.000u
M80 VSS NET_66 NET_63 VSS N33 l=0.350u w=4.000u
M81 VSS NET_61 NET_66 VSS N33 l=0.350u w=5.330u
M82 VSS NET_61 NET_66 VSS N33 l=0.350u w=5.330u
M83 NET_66 NET_61 VSS VSS N33 l=0.350u w=5.330u
M84 VSS NET_57 NET_67 VSS N33 l=0.350u w=5.330u
M85 NET_67 NET_57 VSS VSS N33 l=0.350u w=5.330u
M86 VSS NET_57 NET_67 VSS N33 l=0.350u w=5.330u
M87 NET_77 OEN VSS VSS N33 l=0.350u w=7.440u
M88 NET_77 OEN VSS VSS N33 l=0.350u w=7.440u
M89 VSS NET_79 NET_75 VSS N33 l=0.350u w=7.440u
M90 NET_75 NET_79 VSS VSS N33 l=0.350u w=7.440u
M91 NET_56 NET_3419 NET_54 VSS N33 l=0.350u w=8.000u
M92 NET_56 NET_77 VSS VSS N33 l=0.350u w=8.000u
M93 NET_96 NET_87 VSS VSS N33 l=0.350u w=8.000u
M94 VSS NET_82 NET_10 VSS N33 l=0.350u w=8.000u
M95 VSS NET_82 NET_10 VSS N33 l=0.350u w=8.000u
M96 NET_53 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M97 NET_53 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M98 NET_90 VDD33 NET_53 VSS N33 l=0.350u w=8.000u
M99 NET_102 NET_90 VSS VSS N33 l=0.350u w=7.600u
M100 NET_102 NET_90 VSS VSS N33 l=0.350u w=7.600u
M101 VSS NET_102 NET_114 VSS N33 l=0.350u w=2.000u
M102 VSS NET_102 NET_114 VSS N33 l=0.350u w=2.000u
M103 NET_6016 NET_3419 VDD33 NET_1282 P33 l=0.300u w=30.000u
M104 NET_6016 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M105 NET_6018 NET_3419 VDD33 NET_1282 P33 l=0.300u w=30.000u
M106 NET_6018 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M107 NET_1282 NET_1282 NET_1282 NET_1282 P33 l=1.070u w=5.000u
M108 VDD NET_102 NET_114 VDD P33 l=0.300u w=5.000u
M109 PAD NET_54 NET_6009 NET_1282 P33 l=0.300u w=30.000u
M110 VDD33 NET_3419 NET_6009 NET_1282 P33 l=0.300u w=30.000u
M111 VDD33 NET_6091 NET_6007 NET_1282 P33 l=0.300u w=30.000u
M112 NET_6007 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M113 PAD NET_54 NET_6014 NET_1282 P33 l=0.300u w=30.000u
M114 VDD33 NET_3419 NET_6014 NET_1282 P33 l=0.300u w=30.000u
M115 VDD33 NET_6091 NET_6012 NET_1282 P33 l=0.300u w=30.000u
M116 NET_6012 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M117 NET_102 NET_90 NET_3453 VDD33 P33 l=0.300u w=5.000u
M118 NET_102 NET_90 NET_3453 VDD33 P33 l=0.300u w=5.000u
M119 NET_102 NET_90 NET_3453 VDD33 P33 l=0.300u w=5.000u
M120 NET_102 NET_90 NET_3453 VDD33 P33 l=0.300u w=5.000u
M121 NET_3453 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M122 VDD33 NET_53 NET_3453 VDD33 P33 l=0.300u w=5.000u
M123 NET_3453 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 VDD NET_102 NET_114 VDD P33 l=0.300u w=5.000u
M125 VDD NET_102 NET_114 VDD P33 l=0.300u w=5.000u
M126 NET_114 NET_102 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_102 NET_114 VDD P33 l=0.300u w=5.000u
M128 PAD NET_54 NET_6005 NET_1282 P33 l=0.300u w=30.000u
M129 PAD NET_54 NET_6010 NET_1282 P33 l=0.300u w=30.000u
M130 NET_5999 NET_6092 VDD33 NET_1282 P33 l=0.300u w=30.000u
M131 NET_5999 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M132 PAD NET_54 NET_5997 NET_1282 P33 l=0.300u w=30.000u
M133 NET_6004 NET_6092 VDD33 NET_1282 P33 l=0.300u w=30.000u
M134 NET_6004 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M135 PAD NET_54 NET_6002 NET_1282 P33 l=0.300u w=30.000u
M136 VDD33 NET_10 NET_51 VDD33 P33 l=0.300u w=5.000u
M137 VDD33 NET_10 NET_51 VDD33 P33 l=0.300u w=5.000u
M138 NET_6005 NET_6091 VDD33 NET_1282 P33 l=0.300u w=30.000u
M139 NET_6010 NET_6091 VDD33 NET_1282 P33 l=0.300u w=30.000u
M140 VDD33 NET_6095 NET_5995 NET_1282 P33 l=0.300u w=30.000u
M141 NET_5995 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M142 VDD33 NET_6095 NET_6000 NET_1282 P33 l=0.300u w=30.000u
M143 NET_6000 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M144 NET_5985 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M145 NET_5985 NET_6095 VDD33 NET_1282 P33 l=0.300u w=30.000u
M146 NET_5990 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M147 NET_5990 NET_6095 VDD33 NET_1282 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3419 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_10 NET_96 VDD33 P33 l=0.300u w=5.000u
M150 NET_10 NET_96 VDD33 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_6097 NET_5983 NET_1282 P33 l=0.300u w=30.000u
M152 NET_5983 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M153 PAD NET_54 NET_5981 NET_1282 P33 l=0.300u w=30.000u
M154 VDD33 NET_6097 NET_5988 NET_1282 P33 l=0.300u w=30.000u
M155 NET_5988 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M156 PAD NET_54 NET_5986 NET_1282 P33 l=0.300u w=30.000u
M157 VDD33 NET_77 NET_75 VDD33 P33 l=0.300u w=5.000u
M158 VDD33 NET_75 NET_77 VDD33 P33 l=0.300u w=5.000u
M159 NET_5972 NET_63 VDD33 NET_1282 P33 l=0.300u w=30.000u
M160 NET_5976 NET_63 VDD33 NET_1282 P33 l=0.300u w=30.000u
M161 NET_5981 NET_6097 VDD33 NET_1282 P33 l=0.300u w=30.000u
M162 NET_5986 NET_6097 VDD33 NET_1282 P33 l=0.300u w=30.000u
M163 PAD NET_54 NET_5970 NET_1282 P33 l=0.300u w=30.000u
M164 NET_5970 NET_63 VDD33 NET_1282 P33 l=0.300u w=30.000u
M165 PAD NET_54 NET_5974 NET_1282 P33 l=0.300u w=30.000u
M166 NET_5974 NET_63 VDD33 NET_1282 P33 l=0.300u w=30.000u
M167 NET_1282 PAD VDD33 NET_1282 P33 l=0.350u w=5.000u
M168 NET_1282 PAD VDD33 NET_1282 P33 l=0.350u w=5.000u
M169 VDD33 PAD NET_1282 NET_1282 P33 l=0.350u w=5.000u
M170 VDD33 NET_66 NET_63 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_66 NET_63 VDD33 P33 l=0.300u w=5.000u
M172 NET_63 NET_66 VDD33 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_66 NET_63 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_66 NET_67 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_67 NET_66 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_53 NET_3453 VDD33 P33 l=0.300u w=5.000u
M177 NET_5997 NET_6092 VDD33 NET_1282 P33 l=0.300u w=30.000u
M178 NET_6002 NET_6092 VDD33 NET_1282 P33 l=0.300u w=30.000u
M179 NET_5972 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M180 NET_5976 NET_54 PAD NET_1282 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_54 NET_1282 P33 l=0.350u w=10.000u
M182 PAD VDD33 NET_1282 NET_1282 P33 l=0.350u w=15.000u
R1 PAD NET_53 300.135
R2 NET_24 NET_25 1695.72
R3 NET_49 NET_27 1695.72
R4 NET_51 NET_49 1695.72
R5 NET_25 NET_27 1695.72
R6 NET_63 NET_6097 883.184
R7 NET_6095 NET_6092 883.184
R8 NET_6092 NET_6091 883.184
R9 NET_6095 NET_6097 883.184
.ends PCI3B

.subckt PDIODE8 VSS1 VSS2
DD1 NET_32 VSS1 PDIO33 area=170.013p pj=62.208u
DD2 NET_39 NET_32 PDIO33 area=170.013p pj=62.208u
DD3 NET_28 VSS2 PDIO33 area=170.013p pj=62.208u
DD4 VSS1 NET_43 PDIO33 area=170.013p pj=62.208u
DD5 NET_43 NET_28 PDIO33 area=170.013p pj=62.208u
DD6 VSS2 NET_39 PDIO33 area=170.013p pj=62.208u
.ends PDIODE8

.subckt PDIODE  VSS1 VSS2 VDD1 VDD2
DD1 VDD2 NET_3710 PDIO33 area=207.798p pj=73.208u
DD2 NET_3710 NET_3695 PDIO33 area=207.798p pj=73.208u
DD3 NET_2422 NET_2437 PDIO33 area=207.798p pj=73.208u
DD4 VDD1 NET_2422 PDIO33 area=207.798p pj=73.208u
DD5 NET_3695 VDD1 PDIO33 area=207.798p pj=73.208u
DD6 NET_2437 VDD2 PDIO33 area=207.798p pj=73.208u
DD7 VSS2 NET_978 PDIO33 area=170.013p pj=62.208u
DD8 NET_957 VSS1 PDIO33 area=170.013p pj=62.208u
DD9 NET_978 NET_957 PDIO33 area=170.013p pj=62.208u
DD10 NET_21 VSS2 PDIO33 area=170.013p pj=62.208u
DD11 VSS1 NET_8 PDIO33 area=170.013p pj=62.208u
DD12 NET_8 NET_21 PDIO33 area=170.013p pj=62.208u
.ends PDIODE

.subckt PANA2AP  PAD
M1 NET_54 NET_50 SAVSS SAVSS N33 l=0.350u w=2.500u
M2 NET_54 NET_50 SAVSS SAVSS N33 l=0.350u w=2.500u
M3 SAVSS NET_50 NET_54 SAVSS N33 l=0.350u w=2.500u
M4 NET_54 NET_50 SAVSS SAVSS N33 l=0.350u w=2.500u
M5 SAVSS NET_48 NET_50 SAVSS N33 l=0.350u w=2.500u
M6 NET_50 NET_48 SAVSS SAVSS N33 l=0.350u w=2.500u
M7 SAVSS NET_48 NET_50 SAVSS N33 l=0.350u w=2.500u
M8 NET_50 NET_48 SAVSS SAVSS N33 l=0.350u w=2.500u
M9 SAVSS NET_5198 NET_48 SAVSS N33 l=0.350u w=2.500u
M10 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M11 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M12 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M13 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M14 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M15 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M16 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M17 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M18 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M19 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M20 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M21 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M22 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M23 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M24 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M25 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M26 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M27 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M28 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M29 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M30 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M31 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M32 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M33 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M34 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M35 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M36 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M37 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M38 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M39 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M40 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M41 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M42 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M43 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M44 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M45 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M46 NET_54 NET_50 SAVDD SAVDD P33 l=0.350u w=2.500u
M47 NET_54 NET_50 SAVDD SAVDD P33 l=0.350u w=2.500u
M48 SAVDD NET_50 NET_54 SAVDD P33 l=0.350u w=2.500u
M49 NET_54 NET_50 SAVDD SAVDD P33 l=0.350u w=2.500u
M50 SAVDD NET_48 NET_50 SAVDD P33 l=0.350u w=2.500u
M51 NET_50 NET_48 SAVDD SAVDD P33 l=0.350u w=2.500u
M52 SAVDD NET_5198 NET_48 SAVDD P33 l=0.350u w=2.500u
M53 NET_48 NET_5198 SAVDD SAVDD P33 l=0.350u w=2.500u
M54 SAVDD NET_5198 NET_48 SAVDD P33 l=0.350u w=2.500u
M55 NET_7502 SAVSS NET_5198 SAVDD P33 l=7.120u w=0.300u
M56 NET_7502 SAVSS NET_7501 SAVDD P33 l=7.120u w=0.300u
M57 SAVDD SAVSS NET_7501 SAVDD P33 l=7.120u w=0.300u
M58 SAVSS NET_5198 SAVSS SAVSS C2 l=4.960u w=19.941u
M59 SAVSS NET_5198 SAVSS SAVSS C2 l=4.960u w=19.941u
DD1 SAVSS PAD NDIO33 area=306.710p pj=78.488u
DD2 PAD SAVDD PDIO33 area=128.999p pj=63.094u
.ends PANA2AP

.subckt PISD   PAD C FP
M1 VSS NET_56 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_56 C VSS N18 l=0.180u w=2.000u
M3 C NET_56 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_56 C VSS N18 l=0.180u w=2.000u
M5 C NET_56 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_56 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_59 NET_56 VSS N18 l=0.180u w=2.000u
M8 VSS NET_59 NET_56 VSS N18 l=0.180u w=2.000u
M9 VDD NET_56 C VDD P18 l=0.180u w=5.000u
M10 VDD NET_56 C VDD P18 l=0.180u w=5.000u
M11 C NET_56 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_56 C VDD P18 l=0.180u w=5.000u
M13 C NET_56 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_56 C VDD P18 l=0.180u w=5.000u
M15 VDD NET_59 NET_56 VDD P18 l=0.180u w=5.000u
M16 VDD NET_59 NET_56 VDD P18 l=0.180u w=5.000u
M17 NET_65 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M18 NET_65 FP PAD VSSD N33 l=0.400u w=28.000u
M19 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M20 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M21 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M22 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M23 PAD FP NET_29 VSSD N33 l=0.400u w=28.000u
M24 NET_29 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M25 VSSD NET_23 NET_27 VSSD N33 l=0.400u w=28.000u
M26 NET_27 FP PAD VSSD N33 l=0.400u w=28.000u
M27 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M28 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M29 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M30 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M31 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M32 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M33 NET_67 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M34 NET_67 FP PAD VSSD N33 l=0.400u w=28.000u
M35 NET_40 FP PAD VSSD N33 l=0.400u w=28.000u
M36 NET_40 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_23 NET_38 VSSD N33 l=0.400u w=28.000u
M38 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M39 PAD FP NET_36 VSSD N33 l=0.400u w=28.000u
M40 NET_36 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_23 NET_34 VSSD N33 l=0.400u w=28.000u
M42 NET_34 FP PAD VSSD N33 l=0.400u w=28.000u
M43 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M46 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M47 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M48 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M49 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M50 NET_26 NET_3554 NET_24 VSS N33 l=0.350u w=8.000u
M51 NET_26 VSS VSS VSS N33 l=0.350u w=8.000u
M52 NET_43 VDD33 NET_42 VSS N33 l=0.350u w=8.000u
M53 NET_43 VDD33 NET_42 VSS N33 l=0.350u w=8.000u
M54 NET_42 VDD33 NET_43 VSS N33 l=0.350u w=8.000u
M55 NET_48 NET_42 NET_46 VSS N33 l=0.350u w=8.000u
M56 NET_48 NET_42 VSS VSS N33 l=0.350u w=8.000u
M57 NET_48 NET_46 VDD33 VSS N33 l=0.350u w=0.820u
M58 NET_42 VDD33 VSS VSS N33 l=4.550u w=0.800u
M59 VSS NET_46 NET_59 VSS N33 l=0.350u w=2.000u
M60 VSS NET_46 NET_59 VSS N33 l=0.350u w=2.000u
M61 NET_6236 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M62 NET_6238 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M63 VSS NET_46 NET_3654 VDD33 P33 l=0.300u w=5.100u
M64 NET_6222 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M65 NET_6222 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M66 VDD33 NET_3554 NET_6220 NET_1324 P33 l=0.300u w=30.000u
M67 NET_6220 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M68 NET_6227 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M69 NET_6227 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M70 VDD33 NET_3554 NET_6225 NET_1324 P33 l=0.300u w=30.000u
M71 NET_6225 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M72 NET_46 NET_42 NET_3654 VDD33 P33 l=0.300u w=5.000u
M73 VSS NET_46 NET_3654 VDD33 P33 l=0.300u w=5.100u
M74 VSS NET_46 NET_3654 VDD33 P33 l=0.300u w=5.100u
M75 VSS NET_46 NET_3654 VDD33 P33 l=0.300u w=5.100u
M76 NET_59 NET_46 VDD VDD P33 l=0.300u w=5.000u
M77 NET_59 NET_46 VDD VDD P33 l=0.300u w=5.000u
M78 VDD NET_46 NET_59 VDD P33 l=0.300u w=5.000u
M79 NET_59 NET_46 VDD VDD P33 l=0.300u w=5.000u
M80 VDD NET_46 NET_59 VDD P33 l=0.300u w=5.000u
M81 PAD NET_24 NET_6218 NET_1324 P33 l=0.300u w=30.000u
M82 NET_6218 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M83 VDD33 NET_3554 NET_6210 NET_1324 P33 l=0.300u w=30.000u
M84 NET_6210 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M85 PAD NET_24 NET_6223 NET_1324 P33 l=0.300u w=30.000u
M86 NET_6223 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M87 VDD33 NET_3554 NET_6216 NET_1324 P33 l=0.300u w=30.000u
M88 NET_6216 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M89 NET_46 NET_42 NET_3654 VDD33 P33 l=0.300u w=5.000u
M90 NET_3654 NET_43 VDD33 VDD33 P33 l=0.300u w=5.000u
M91 VDD33 NET_43 NET_3654 VDD33 P33 l=0.300u w=5.000u
M92 PAD NET_24 NET_6208 NET_1324 P33 l=0.300u w=30.000u
M93 NET_6208 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M94 VDD33 NET_3554 NET_6206 NET_1324 P33 l=0.300u w=30.000u
M95 NET_6206 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M96 PAD NET_24 NET_6214 NET_1324 P33 l=0.300u w=30.000u
M97 NET_6214 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M98 VDD33 NET_3554 NET_6212 NET_1324 P33 l=0.300u w=30.000u
M99 NET_6212 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M100 NET_6198 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M101 NET_6198 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M102 VDD33 NET_3554 NET_6196 NET_1324 P33 l=0.300u w=30.000u
M103 NET_6196 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M104 PAD NET_24 NET_6185 NET_1324 P33 l=0.300u w=30.000u
M105 NET_6201 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M106 NET_6201 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M107 VDD33 NET_3554 NET_6199 NET_1324 P33 l=0.300u w=30.000u
M108 NET_6199 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M109 PAD NET_24 NET_6191 NET_1324 P33 l=0.300u w=30.000u
M110 VDD33 VSS NET_3554 VDD33 P33 l=0.300u w=5.000u
M111 VDD33 NET_3554 NET_6183 NET_1324 P33 l=0.300u w=30.000u
M112 NET_6183 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M113 PAD NET_24 NET_6181 NET_1324 P33 l=0.300u w=30.000u
M114 NET_6181 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M115 VDD33 NET_3554 NET_6189 NET_1324 P33 l=0.300u w=30.000u
M116 NET_6189 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M117 PAD NET_24 NET_6187 NET_1324 P33 l=0.300u w=30.000u
M118 NET_6187 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M119 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M120 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M121 VDD33 PAD NET_1324 NET_1324 P33 l=0.350u w=5.000u
M122 NET_6236 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M123 NET_6185 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M124 NET_6238 NET_24 PAD NET_1324 P33 l=0.300u w=30.000u
M125 NET_6191 NET_3554 VDD33 NET_1324 P33 l=0.300u w=30.000u
M126 PAD VDD33 NET_1324 NET_1324 P33 l=0.350u w=15.000u
M127 PAD VDD33 NET_24 NET_1324 P33 l=0.350u w=10.000u
M128 NET_1324 NET_1324 NET_1324 NET_1324 P33 l=1.070u w=5.000u
R1 PAD NET_43 300.135
.ends PISD

.subckt PVSS3AP  SAVSS
M1 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M2 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M3 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M4 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M5 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M6 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M7 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M8 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M9 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M10 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M11 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M12 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M13 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M14 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M15 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M16 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M17 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M18 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M19 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M20 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M21 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M22 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M23 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M24 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M25 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M26 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M27 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M28 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M29 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M30 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M31 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M32 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
.ends PVSS3AP

.subckt PVSS2AP   SAVSSD
M1 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M2 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M3 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M4 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M5 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M6 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M7 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M8 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M9 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M10 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M11 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M12 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M13 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M14 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M15 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M16 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M17 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M18 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M19 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M20 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M21 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M22 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M23 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M24 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M25 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M26 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M27 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M28 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M29 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M30 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M31 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M32 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
.ends PVSS2AP

.subckt PVDD5AP  SAVDD
M1 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M2 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M3 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M4 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M5 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M6 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M7 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M8 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M9 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M10 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M11 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M12 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M13 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M14 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M15 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M16 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M17 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M18 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M19 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M20 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M21 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M22 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M23 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M24 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M25 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M26 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M27 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M28 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M29 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M30 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M31 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M32 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
.ends PVDD5AP

.subckt PVDD3AP  SAVDD
M1 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M2 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M3 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M4 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M5 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M6 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M7 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M8 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M9 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M10 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M11 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M12 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M13 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M14 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M15 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M16 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M17 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M18 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M19 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M20 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M21 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M22 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M23 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M24 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M25 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M26 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M27 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M28 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M29 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M30 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M31 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M32 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
.ends PVDD3AP

.subckt PVDD2AP   SAVDD33
M1 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M2 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M3 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M4 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M5 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M6 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M7 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M8 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M9 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M10 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M11 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M12 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M13 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M14 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M15 SAVSSD SAVSSD SAVDD33 SAVSSD N33 l=0.350u w=28.000u
M16 SAVDD33 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M17 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M18 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M19 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M20 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M21 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M22 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M23 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M24 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M25 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M26 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M27 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M28 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M29 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M30 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M31 SAVDD33 SAVDD33 SAVSSD SAVDD33 P33 l=0.300u w=30.000u
M32 SAVSSD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
.ends PVDD2AP

.subckt PVSS5AP  SAVSS
M1 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M2 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M3 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M4 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M5 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M6 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M7 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M8 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M9 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M10 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M11 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M12 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M13 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M14 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M15 SAVSS SAVSS SAVDD SAVSS N33 l=0.350u w=28.000u
M16 SAVDD SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M17 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M18 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M19 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M20 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M21 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M22 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M23 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M24 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M25 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M26 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M27 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M28 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M29 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M30 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M31 SAVDD SAVDD SAVSS SAVDD P33 l=0.300u w=30.000u
M32 SAVSS SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
.ends PVSS5AP

.subckt PVSS4AP  SAVSS
M1 SAVSS SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M2 SAVSS SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M3 SAVSSD SAVSSD SAVSS SAVSSD N33 l=0.350u w=28.000u
M4 SAVSS SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M5 SAVSSD SAVSSD SAVSS SAVSSD N33 l=0.350u w=28.000u
M6 SAVSS SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M7 SAVSSD SAVSSD SAVSS SAVSSD N33 l=0.350u w=28.000u
M8 SAVSS SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M9 SAVSS SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M10 SAVSS SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M11 SAVSSD SAVSSD SAVSS SAVSSD N33 l=0.350u w=28.000u
M12 SAVSS SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M13 SAVSSD SAVSSD SAVSS SAVSSD N33 l=0.350u w=28.000u
M14 SAVSS SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M15 SAVSSD SAVSSD SAVSS SAVSSD N33 l=0.350u w=28.000u
M16 SAVSS SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M17 SAVSS SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M18 SAVSS SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M19 SAVDD33 SAVDD33 SAVSS SAVDD33 P33 l=0.300u w=30.000u
M20 SAVSS SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M21 SAVDD33 SAVDD33 SAVSS SAVDD33 P33 l=0.300u w=30.000u
M22 SAVSS SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M23 SAVDD33 SAVDD33 SAVSS SAVDD33 P33 l=0.300u w=30.000u
M24 SAVSS SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M25 SAVSS SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M26 SAVSS SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M27 SAVDD33 SAVDD33 SAVSS SAVDD33 P33 l=0.300u w=30.000u
M28 SAVSS SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M29 SAVDD33 SAVDD33 SAVSS SAVDD33 P33 l=0.300u w=30.000u
M30 SAVSS SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M31 SAVDD33 SAVDD33 SAVSS SAVDD33 P33 l=0.300u w=30.000u
M32 SAVSS SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
.ends PVSS4AP

.subckt PVSS1AP1   SVSS1AP1
M1 SVSS1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M2 SVSS1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M3 SAVSSD SAVSSD SVSS1AP1 SAVSSD N33 l=0.350u w=28.000u
M4 SVSS1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M5 SAVSSD SAVSSD SVSS1AP1 SAVSSD N33 l=0.350u w=28.000u
M6 SVSS1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M7 SAVSSD SAVSSD SVSS1AP1 SAVSSD N33 l=0.350u w=28.000u
M8 SVSS1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M9 SVSS1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M10 SVSS1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M11 SAVSSD SAVSSD SVSS1AP1 SAVSSD N33 l=0.350u w=28.000u
M12 SVSS1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M13 SAVSSD SAVSSD SVSS1AP1 SAVSSD N33 l=0.350u w=28.000u
M14 SVSS1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M15 SAVSSD SAVSSD SVSS1AP1 SAVSSD N33 l=0.350u w=28.000u
M16 SVSS1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M17 SVSS1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M18 SVSS1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M19 SAVDD33 SAVDD33 SVSS1AP1 SAVDD33 P33 l=0.300u w=30.000u
M20 SVSS1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M21 SAVDD33 SAVDD33 SVSS1AP1 SAVDD33 P33 l=0.300u w=30.000u
M22 SVSS1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M23 SAVDD33 SAVDD33 SVSS1AP1 SAVDD33 P33 l=0.300u w=30.000u
M24 SVSS1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M25 SVSS1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M26 SVSS1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M27 SAVDD33 SAVDD33 SVSS1AP1 SAVDD33 P33 l=0.300u w=30.000u
M28 SVSS1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M29 SAVDD33 SAVDD33 SVSS1AP1 SAVDD33 P33 l=0.300u w=30.000u
M30 SVSS1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M31 SAVDD33 SAVDD33 SVSS1AP1 SAVDD33 P33 l=0.300u w=30.000u
M32 SVSS1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
.ends PVSS1AP1

.subckt PVSS1AP  SVSS1AP
M1 SVSS1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M2 SVSS1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M3 SAVSS SAVSS SVSS1AP SAVSS N33 l=0.350u w=28.000u
M4 SVSS1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M5 SAVSS SAVSS SVSS1AP SAVSS N33 l=0.350u w=28.000u
M6 SVSS1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M7 SAVSS SAVSS SVSS1AP SAVSS N33 l=0.350u w=28.000u
M8 SVSS1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M9 SVSS1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M10 SVSS1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M11 SAVSS SAVSS SVSS1AP SAVSS N33 l=0.350u w=28.000u
M12 SVSS1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M13 SAVSS SAVSS SVSS1AP SAVSS N33 l=0.350u w=28.000u
M14 SVSS1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M15 SAVSS SAVSS SVSS1AP SAVSS N33 l=0.350u w=28.000u
M16 SVSS1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M17 SVSS1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M18 SVSS1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M19 SAVDD SAVDD SVSS1AP SAVDD P33 l=0.300u w=30.000u
M20 SVSS1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M21 SAVDD SAVDD SVSS1AP SAVDD P33 l=0.300u w=30.000u
M22 SVSS1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M23 SAVDD SAVDD SVSS1AP SAVDD P33 l=0.300u w=30.000u
M24 SVSS1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M25 SVSS1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M26 SVSS1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M27 SAVDD SAVDD SVSS1AP SAVDD P33 l=0.300u w=30.000u
M28 SVSS1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M29 SAVDD SAVDD SVSS1AP SAVDD P33 l=0.300u w=30.000u
M30 SVSS1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M31 SAVDD SAVDD SVSS1AP SAVDD P33 l=0.300u w=30.000u
M32 SVSS1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
.ends PVSS1AP

.subckt PVDD4AP   SAVDD
M1 SAVDD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M2 SAVDD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M3 SAVSSD SAVSSD SAVDD SAVSSD N33 l=0.350u w=28.000u
M4 SAVDD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M5 SAVSSD SAVSSD SAVDD SAVSSD N33 l=0.350u w=28.000u
M6 SAVDD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M7 SAVSSD SAVSSD SAVDD SAVSSD N33 l=0.350u w=28.000u
M8 SAVDD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M9 SAVDD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M10 SAVDD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M11 SAVSSD SAVSSD SAVDD SAVSSD N33 l=0.350u w=28.000u
M12 SAVDD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M13 SAVSSD SAVSSD SAVDD SAVSSD N33 l=0.350u w=28.000u
M14 SAVDD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M15 SAVSSD SAVSSD SAVDD SAVSSD N33 l=0.350u w=28.000u
M16 SAVDD SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M17 SAVDD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M18 SAVDD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M19 SAVDD33 SAVDD33 SAVDD SAVDD33 P33 l=0.300u w=30.000u
M20 SAVDD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M21 SAVDD33 SAVDD33 SAVDD SAVDD33 P33 l=0.300u w=30.000u
M22 SAVDD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M23 SAVDD33 SAVDD33 SAVDD SAVDD33 P33 l=0.300u w=30.000u
M24 SAVDD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M25 SAVDD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M26 SAVDD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M27 SAVDD33 SAVDD33 SAVDD SAVDD33 P33 l=0.300u w=30.000u
M28 SAVDD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M29 SAVDD33 SAVDD33 SAVDD SAVDD33 P33 l=0.300u w=30.000u
M30 SAVDD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M31 SAVDD33 SAVDD33 SAVDD SAVDD33 P33 l=0.300u w=30.000u
M32 SAVDD SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
.ends PVDD4AP

.subckt PVDD1AP1   SVDD1AP1
M1 SVDD1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M2 SVDD1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M3 SAVSSD SAVSSD SVDD1AP1 SAVSSD N33 l=0.350u w=28.000u
M4 SVDD1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M5 SAVSSD SAVSSD SVDD1AP1 SAVSSD N33 l=0.350u w=28.000u
M6 SVDD1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M7 SAVSSD SAVSSD SVDD1AP1 SAVSSD N33 l=0.350u w=28.000u
M8 SVDD1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M9 SVDD1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M10 SVDD1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M11 SAVSSD SAVSSD SVDD1AP1 SAVSSD N33 l=0.350u w=28.000u
M12 SVDD1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M13 SAVSSD SAVSSD SVDD1AP1 SAVSSD N33 l=0.350u w=28.000u
M14 SVDD1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M15 SAVSSD SAVSSD SVDD1AP1 SAVSSD N33 l=0.350u w=28.000u
M16 SVDD1AP1 SAVSSD SAVSSD SAVSSD N33 l=0.350u w=28.000u
M17 SVDD1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M18 SVDD1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M19 SAVDD33 SAVDD33 SVDD1AP1 SAVDD33 P33 l=0.300u w=30.000u
M20 SVDD1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M21 SAVDD33 SAVDD33 SVDD1AP1 SAVDD33 P33 l=0.300u w=30.000u
M22 SVDD1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M23 SAVDD33 SAVDD33 SVDD1AP1 SAVDD33 P33 l=0.300u w=30.000u
M24 SVDD1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M25 SVDD1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M26 SVDD1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M27 SAVDD33 SAVDD33 SVDD1AP1 SAVDD33 P33 l=0.300u w=30.000u
M28 SVDD1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M29 SAVDD33 SAVDD33 SVDD1AP1 SAVDD33 P33 l=0.300u w=30.000u
M30 SVDD1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M31 SAVDD33 SAVDD33 SVDD1AP1 SAVDD33 P33 l=0.300u w=30.000u
M32 SVDD1AP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
.ends PVDD1AP1

.subckt PVDD1AP  SVDD1AP
M1 SVDD1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M2 SVDD1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M3 SAVSS SAVSS SVDD1AP SAVSS N33 l=0.350u w=28.000u
M4 SVDD1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M5 SAVSS SAVSS SVDD1AP SAVSS N33 l=0.350u w=28.000u
M6 SVDD1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M7 SAVSS SAVSS SVDD1AP SAVSS N33 l=0.350u w=28.000u
M8 SVDD1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M9 SVDD1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M10 SVDD1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M11 SAVSS SAVSS SVDD1AP SAVSS N33 l=0.350u w=28.000u
M12 SVDD1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M13 SAVSS SAVSS SVDD1AP SAVSS N33 l=0.350u w=28.000u
M14 SVDD1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M15 SAVSS SAVSS SVDD1AP SAVSS N33 l=0.350u w=28.000u
M16 SVDD1AP SAVSS SAVSS SAVSS N33 l=0.350u w=28.000u
M17 SVDD1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M18 SVDD1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M19 SAVDD SAVDD SVDD1AP SAVDD P33 l=0.300u w=30.000u
M20 SVDD1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M21 SAVDD SAVDD SVDD1AP SAVDD P33 l=0.300u w=30.000u
M22 SVDD1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M23 SAVDD SAVDD SVDD1AP SAVDD P33 l=0.300u w=30.000u
M24 SVDD1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M25 SVDD1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M26 SVDD1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M27 SAVDD SAVDD SVDD1AP SAVDD P33 l=0.300u w=30.000u
M28 SVDD1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M29 SAVDD SAVDD SVDD1AP SAVDD P33 l=0.300u w=30.000u
M30 SVDD1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M31 SAVDD SAVDD SVDD1AP SAVDD P33 l=0.300u w=30.000u
M32 SVDD1AP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
.ends PVDD1AP

.subckt PVSS3    VSS
M1 VDD33 VSS VSS VSS N33 l=0.350u w=28.000u
M2 VDD33 VSS VSS VSS N33 l=0.350u w=28.000u
M3 VSS VSS VDD33 VSS N33 l=0.350u w=28.000u
M4 VDD33 VSS VSS VSS N33 l=0.350u w=28.000u
M5 VSS VSS VDD33 VSS N33 l=0.350u w=28.000u
M6 VDD33 VSS VSS VSS N33 l=0.350u w=28.000u
M7 VSS VSS VDD33 VSS N33 l=0.350u w=28.000u
M8 VDD33 VSS VSS VSS N33 l=0.350u w=28.000u
M9 VDD33 VSS VSS VSS N33 l=0.350u w=28.000u
M10 VDD33 VSS VSS VSS N33 l=0.350u w=28.000u
M11 VSS VSS VDD33 VSS N33 l=0.350u w=28.000u
M12 VDD33 VSS VSS VSS N33 l=0.350u w=28.000u
M13 VSS VSS VDD33 VSS N33 l=0.350u w=28.000u
M14 VDD33 VSS VSS VSS N33 l=0.350u w=28.000u
M15 VSS VSS VDD33 VSS N33 l=0.350u w=28.000u
M16 VDD33 VSS VSS VSS N33 l=0.350u w=28.000u
M17 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M18 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M19 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M20 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M21 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M22 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M23 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M24 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M25 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M26 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M27 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M28 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M29 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M30 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M31 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M32 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
.ends PVSS3

.subckt PVSS2    VSSD
M1 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M2 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M3 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M4 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M5 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M6 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M7 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M8 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M9 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M10 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M11 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M12 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M13 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M14 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M15 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M16 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M17 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M18 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M19 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M20 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M21 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M22 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M23 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M24 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M25 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M26 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M27 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M28 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M29 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M30 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M31 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M32 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
.ends PVSS2

.subckt PVSS1    VSS
M1 VSS VSSD VSSD VSSD N18 l=0.180u w=28.000u
M2 VSS VSSD VSSD VSSD N18 l=0.180u w=28.000u
M3 VSSD VSSD VSS VSSD N18 l=0.180u w=28.000u
M4 VSS VSSD VSSD VSSD N18 l=0.180u w=28.000u
M5 VSSD VSSD VSS VSSD N18 l=0.180u w=28.000u
M6 VSS VSSD VSSD VSSD N18 l=0.180u w=28.000u
M7 VSSD VSSD VSS VSSD N18 l=0.180u w=28.000u
M8 VSS VSSD VSSD VSSD N18 l=0.180u w=28.000u
M9 VSS VSSD VSSD VSSD N18 l=0.180u w=28.000u
M10 VSS VSSD VSSD VSSD N18 l=0.180u w=28.000u
M11 VSSD VSSD VSS VSSD N18 l=0.180u w=28.000u
M12 VSS VSSD VSSD VSSD N18 l=0.180u w=28.000u
M13 VSSD VSSD VSS VSSD N18 l=0.180u w=28.000u
M14 VSS VSSD VSSD VSSD N18 l=0.180u w=28.000u
M15 VSSD VSSD VSS VSSD N18 l=0.180u w=28.000u
M16 VSS VSSD VSSD VSSD N18 l=0.180u w=28.000u
M17 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M18 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M19 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M20 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M21 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M22 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M23 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M24 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M25 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M26 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M27 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M28 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M29 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M30 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M31 VDD33 VDD33 VSS VDD33 P33 l=0.300u w=30.000u
M32 VSS VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
.ends PVSS1

.subckt PVDD2   VDD33 FP
M1 FP NET_6 VSS VSS N33 l=0.350u w=2.500u
M2 FP NET_6 VSS VSS N33 l=0.350u w=2.500u
M3 VSS NET_6 FP VSS N33 l=0.350u w=2.500u
M4 FP NET_6 VSS VSS N33 l=0.350u w=2.500u
M5 VSS NET_27 NET_6 VSS N33 l=0.350u w=2.500u
M6 NET_6 NET_27 VSS VSS N33 l=0.350u w=2.500u
M7 VSS NET_27 NET_6 VSS N33 l=0.350u w=2.500u
M8 NET_6 NET_27 VSS VSS N33 l=0.350u w=2.500u
M9 VSS NET_25 NET_27 VSS N33 l=0.350u w=2.500u
M10 NET_27 NET_25 VSS VSS N33 l=0.350u w=2.500u
M11 VSS NET_25 NET_27 VSS N33 l=0.350u w=2.500u
M12 NET_27 NET_25 VSS VSS N33 l=0.350u w=2.500u
M13 VSS NET_2858 NET_25 VSS N33 l=0.350u w=2.500u
M14 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M15 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M16 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M17 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M18 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M19 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M20 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M21 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M22 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M23 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M24 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M25 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M26 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M27 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M28 VSSD VSSD VDD33 VSSD N33 l=0.350u w=28.000u
M29 VDD33 VSSD VSSD VSSD N33 l=0.350u w=28.000u
M30 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M31 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M32 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M33 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M34 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M35 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M36 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M37 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M38 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M39 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M40 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M41 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M42 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M43 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M44 VDD33 VDD33 VSSD VDD33 P33 l=0.300u w=30.000u
M45 VSSD VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M46 FP NET_6 VDD33 VDD33 P33 l=0.350u w=2.500u
M47 FP NET_6 VDD33 VDD33 P33 l=0.350u w=2.500u
M48 VDD33 NET_6 FP VDD33 P33 l=0.350u w=2.500u
M49 FP NET_6 VDD33 VDD33 P33 l=0.350u w=2.500u
M50 VDD33 NET_27 NET_6 VDD33 P33 l=0.350u w=2.500u
M51 NET_6 NET_27 VDD33 VDD33 P33 l=0.350u w=2.500u
M52 VDD33 NET_27 NET_6 VDD33 P33 l=0.350u w=2.500u
M53 NET_6 NET_27 VDD33 VDD33 P33 l=0.350u w=2.500u
M54 VDD33 NET_25 NET_27 VDD33 P33 l=0.350u w=2.500u
M55 NET_27 NET_25 VDD33 VDD33 P33 l=0.350u w=2.500u
M56 VDD33 NET_2858 NET_25 VDD33 P33 l=0.350u w=2.500u
M57 NET_25 NET_2858 VDD33 VDD33 P33 l=0.350u w=2.500u
M58 VDD33 NET_2858 NET_25 VDD33 P33 l=0.350u w=2.500u
M59 NET_4992 VSS NET_2858 VDD33 P33 l=7.120u w=0.300u
M60 NET_4992 VSS NET_4989 VDD33 P33 l=7.120u w=0.300u
M61 VDD33 VSS NET_4989 VDD33 P33 l=7.120u w=0.300u
M62 VSS NET_2858 VSS VSS C2 l=4.960u w=19.941u
M63 VSS NET_2858 VSS VSS C2 l=4.960u w=19.941u
.ends PVDD2

.subckt PVDD1    VDD
M1 VDD VSSD VSSD VSSD N18 l=0.180u w=28.000u
M2 VDD VSSD VSSD VSSD N18 l=0.180u w=28.000u
M3 VSSD VSSD VDD VSSD N18 l=0.180u w=28.000u
M4 VDD VSSD VSSD VSSD N18 l=0.180u w=28.000u
M5 VSSD VSSD VDD VSSD N18 l=0.180u w=28.000u
M6 VDD VSSD VSSD VSSD N18 l=0.180u w=28.000u
M7 VSSD VSSD VDD VSSD N18 l=0.180u w=28.000u
M8 VDD VSSD VSSD VSSD N18 l=0.180u w=28.000u
M9 VDD VSSD VSSD VSSD N18 l=0.180u w=28.000u
M10 VDD VSSD VSSD VSSD N18 l=0.180u w=28.000u
M11 VSSD VSSD VDD VSSD N18 l=0.180u w=28.000u
M12 VDD VSSD VSSD VSSD N18 l=0.180u w=28.000u
M13 VSSD VSSD VDD VSSD N18 l=0.180u w=28.000u
M14 VDD VSSD VSSD VSSD N18 l=0.180u w=28.000u
M15 VSSD VSSD VDD VSSD N18 l=0.180u w=28.000u
M16 VDD VSSD VSSD VSSD N18 l=0.180u w=28.000u
M17 VDD VDD33 VDD33 VDD33 P18 l=0.300u w=30.000u
M18 VDD VDD33 VDD33 VDD33 P18 l=0.300u w=30.000u
M19 VDD33 VDD33 VDD VDD33 P18 l=0.300u w=30.000u
M20 VDD VDD33 VDD33 VDD33 P18 l=0.300u w=30.000u
M21 VDD33 VDD33 VDD VDD33 P18 l=0.300u w=30.000u
M22 VDD VDD33 VDD33 VDD33 P18 l=0.300u w=30.000u
M23 VDD33 VDD33 VDD VDD33 P18 l=0.300u w=30.000u
M24 VDD VDD33 VDD33 VDD33 P18 l=0.300u w=30.000u
M25 VDD VDD33 VDD33 VDD33 P18 l=0.300u w=30.000u
M26 VDD VDD33 VDD33 VDD33 P18 l=0.300u w=30.000u
M27 VDD33 VDD33 VDD VDD33 P18 l=0.300u w=30.000u
M28 VDD VDD33 VDD33 VDD33 P18 l=0.300u w=30.000u
M29 VDD33 VDD33 VDD VDD33 P18 l=0.300u w=30.000u
M30 VDD VDD33 VDD33 VDD33 P18 l=0.300u w=30.000u
M31 VDD33 VDD33 VDD VDD33 P18 l=0.300u w=30.000u
M32 VDD VDD33 VDD33 VDD33 P18 l=0.300u w=30.000u
.ends PVDD1

.subckt PIU   PAD C FP
M1 VSS NET_60 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_60 C VSS N18 l=0.180u w=2.000u
M3 C NET_60 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_60 C VSS N18 l=0.180u w=2.000u
M5 C NET_60 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_60 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_63 NET_60 VSS N18 l=0.180u w=2.000u
M8 VSS NET_63 NET_60 VSS N18 l=0.180u w=2.000u
M9 VDD NET_60 C VDD P18 l=0.180u w=5.000u
M10 VDD NET_60 C VDD P18 l=0.180u w=5.000u
M11 C NET_60 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_60 C VDD P18 l=0.180u w=5.000u
M13 C NET_60 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_60 C VDD P18 l=0.180u w=5.000u
M15 VDD NET_63 NET_60 VDD P18 l=0.180u w=5.000u
M16 VDD NET_63 NET_60 VDD P18 l=0.180u w=5.000u
M17 NET_40 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M18 NET_40 FP PAD VSSD N33 l=0.400u w=28.000u
M19 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M20 NET_30 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M21 VSSD NET_23 NET_28 VSSD N33 l=0.400u w=28.000u
M22 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M23 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M24 NET_26 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M25 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M26 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M27 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M28 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M29 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M30 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M31 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M32 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M33 NET_42 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M34 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M35 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M36 NET_37 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_23 NET_35 VSSD N33 l=0.400u w=28.000u
M38 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M39 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M40 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M42 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M43 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M46 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M47 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M48 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M49 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M50 NET_46 NET_3549 NET_44 VSS N33 l=0.350u w=8.000u
M51 NET_46 VSS VSS VSS N33 l=0.350u w=8.000u
M52 NET_43 VDD33 NET_47 VSS N33 l=0.350u w=8.000u
M53 NET_43 VDD33 NET_47 VSS N33 l=0.350u w=8.000u
M54 NET_47 VDD33 NET_43 VSS N33 l=0.350u w=8.000u
M55 VSS NET_47 NET_51 VSS N33 l=0.350u w=8.000u
M56 VSS NET_51 NET_63 VSS N33 l=0.350u w=2.000u
M57 VSS NET_51 NET_63 VSS N33 l=0.350u w=2.000u
M58 NET_6282 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M59 NET_6284 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M60 VDD NET_51 NET_63 VDD P33 l=0.300u w=5.000u
M61 VDD NET_51 NET_63 VDD P33 l=0.300u w=5.000u
M62 NET_6266 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M63 NET_6266 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M64 VDD33 NET_3549 NET_6264 NET_1319 P33 l=0.300u w=30.000u
M65 NET_6264 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M66 NET_6271 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M67 NET_6271 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M68 VDD33 NET_3549 NET_6269 NET_1319 P33 l=0.300u w=30.000u
M69 NET_6269 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M70 NET_51 NET_47 NET_3649 VDD33 P33 l=0.300u w=5.000u
M71 NET_51 NET_47 NET_3649 VDD33 P33 l=0.300u w=5.000u
M72 NET_3649 NET_47 NET_51 VDD33 P33 l=0.300u w=5.000u
M73 NET_51 NET_47 NET_3649 VDD33 P33 l=0.300u w=5.000u
M74 NET_3649 NET_43 VDD33 VDD33 P33 l=0.300u w=5.000u
M75 NET_63 NET_51 VDD VDD P33 l=0.300u w=5.000u
M76 VDD NET_51 NET_63 VDD P33 l=0.300u w=5.000u
M77 NET_63 NET_51 VDD VDD P33 l=0.300u w=5.000u
M78 VDD NET_51 NET_63 VDD P33 l=0.300u w=5.000u
M79 NET_63 NET_51 VDD VDD P33 l=0.300u w=5.000u
M80 VDD NET_51 NET_63 VDD P33 l=0.300u w=5.000u
M81 PAD NET_44 NET_6262 NET_1319 P33 l=0.300u w=30.000u
M82 NET_6262 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M83 VDD33 NET_3549 NET_6254 NET_1319 P33 l=0.300u w=30.000u
M84 NET_6254 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M85 PAD NET_44 NET_6267 NET_1319 P33 l=0.300u w=30.000u
M86 NET_6267 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M87 VDD33 NET_3549 NET_6260 NET_1319 P33 l=0.300u w=30.000u
M88 NET_6260 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M89 VDD33 NET_43 NET_3649 VDD33 P33 l=0.300u w=5.000u
M90 NET_3649 NET_43 VDD33 VDD33 P33 l=0.300u w=5.000u
M91 VDD33 NET_43 NET_3649 VDD33 P33 l=0.300u w=5.000u
M92 PAD NET_44 NET_6252 NET_1319 P33 l=0.300u w=30.000u
M93 NET_6252 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M94 VDD33 NET_3549 NET_6250 NET_1319 P33 l=0.300u w=30.000u
M95 NET_6250 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M96 PAD NET_44 NET_6258 NET_1319 P33 l=0.300u w=30.000u
M97 NET_6258 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M98 VDD33 NET_3549 NET_6256 NET_1319 P33 l=0.300u w=30.000u
M99 NET_6256 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M100 NET_6242 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M101 NET_6242 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M102 VDD33 NET_3549 NET_6240 NET_1319 P33 l=0.300u w=30.000u
M103 NET_6240 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M104 PAD NET_44 NET_6229 NET_1319 P33 l=0.300u w=30.000u
M105 NET_6245 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M106 NET_6245 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M107 VDD33 NET_3549 NET_6243 NET_1319 P33 l=0.300u w=30.000u
M108 NET_6243 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M109 PAD NET_44 NET_6235 NET_1319 P33 l=0.300u w=30.000u
M110 VDD33 VSS NET_3549 VDD33 P33 l=0.300u w=5.000u
M111 VDD33 NET_3549 NET_6227 NET_1319 P33 l=0.300u w=30.000u
M112 NET_6227 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M113 PAD NET_44 NET_6225 NET_1319 P33 l=0.300u w=30.000u
M114 NET_6225 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M115 VDD33 NET_3549 NET_6233 NET_1319 P33 l=0.300u w=30.000u
M116 NET_6233 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M117 PAD NET_44 NET_6231 NET_1319 P33 l=0.300u w=30.000u
M118 NET_6231 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M119 NET_1319 PAD VDD33 NET_1319 P33 l=0.350u w=5.000u
M120 NET_1319 PAD VDD33 NET_1319 P33 l=0.350u w=5.000u
M121 VDD33 PAD NET_1319 NET_1319 P33 l=0.350u w=5.000u
M122 PAD VDD33 NET_1319 NET_1319 P33 l=0.350u w=15.000u
M123 NET_6282 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M124 NET_6229 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M125 NET_6284 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M126 NET_6235 NET_3549 VDD33 NET_1319 P33 l=0.300u w=30.000u
M127 VDD33 VDD NET_43 NET_1319 P33 l=1.070u w=5.000u
M128 PAD VDD33 NET_44 NET_1319 P33 l=0.350u w=10.000u
R1 PAD NET_43 300.135
.ends PIU

.subckt PISU   PAD C FP
M1 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M3 C NET_57 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M5 C NET_57 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_60 NET_57 VSS N18 l=0.180u w=2.000u
M8 VSS NET_60 NET_57 VSS N18 l=0.180u w=2.000u
M9 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M10 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M11 C NET_57 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M13 C NET_57 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M15 VDD NET_60 NET_57 VDD P18 l=0.180u w=5.000u
M16 VDD NET_60 NET_57 VDD P18 l=0.180u w=5.000u
M17 NET_64 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M18 NET_64 FP PAD VSSD N33 l=0.400u w=28.000u
M19 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M20 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M21 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M22 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M23 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M24 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M25 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M26 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M27 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M28 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M29 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M30 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M31 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M32 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M33 NET_66 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M34 NET_66 FP PAD VSSD N33 l=0.400u w=28.000u
M35 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M36 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M38 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M39 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M40 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M42 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M43 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M46 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M47 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M48 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M49 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M50 NET_42 NET_3552 NET_40 VSS N33 l=0.350u w=8.000u
M51 NET_42 VSS VSS VSS N33 l=0.350u w=8.000u
M52 NET_44 VDD33 NET_43 VSS N33 l=0.350u w=8.000u
M53 NET_44 VDD33 NET_43 VSS N33 l=0.350u w=8.000u
M54 NET_43 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M55 NET_8 NET_43 NET_47 VSS N33 l=0.350u w=8.000u
M56 NET_8 NET_43 VSS VSS N33 l=0.350u w=8.000u
M57 NET_8 NET_47 VDD33 VSS N33 l=0.350u w=0.820u
M58 VSS NET_47 NET_60 VSS N33 l=0.350u w=2.000u
M59 VSS NET_47 NET_60 VSS N33 l=0.350u w=2.000u
M60 NET_6186 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M61 NET_6188 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M62 VSS NET_47 NET_3652 VDD33 P33 l=0.300u w=5.100u
M63 NET_6170 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M64 NET_6170 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M65 VDD33 NET_3552 NET_6168 NET_1322 P33 l=0.300u w=30.000u
M66 NET_6168 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M67 NET_6175 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M68 NET_6175 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M69 VDD33 NET_3552 NET_6173 NET_1322 P33 l=0.300u w=30.000u
M70 NET_6173 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M71 VSS NET_47 NET_3652 VDD33 P33 l=0.300u w=5.100u
M72 VSS NET_47 NET_3652 VDD33 P33 l=0.300u w=5.100u
M73 VSS NET_47 NET_3652 VDD33 P33 l=0.300u w=5.100u
M74 NET_47 NET_43 NET_3652 VDD33 P33 l=0.300u w=5.000u
M75 NET_60 NET_47 VDD VDD P33 l=0.300u w=5.000u
M76 NET_60 NET_47 VDD VDD P33 l=0.300u w=5.000u
M77 VDD NET_47 NET_60 VDD P33 l=0.300u w=5.000u
M78 NET_60 NET_47 VDD VDD P33 l=0.300u w=5.000u
M79 VDD NET_47 NET_60 VDD P33 l=0.300u w=5.000u
M80 PAD NET_40 NET_6166 NET_1322 P33 l=0.300u w=30.000u
M81 NET_6166 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M82 VDD33 NET_3552 NET_6158 NET_1322 P33 l=0.300u w=30.000u
M83 NET_6158 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M84 PAD NET_40 NET_6171 NET_1322 P33 l=0.300u w=30.000u
M85 NET_6171 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M86 VDD33 NET_3552 NET_6164 NET_1322 P33 l=0.300u w=30.000u
M87 NET_6164 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M88 NET_47 NET_43 NET_3652 VDD33 P33 l=0.300u w=5.000u
M89 NET_3652 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M90 VDD33 NET_44 NET_3652 VDD33 P33 l=0.300u w=5.000u
M91 PAD NET_40 NET_6156 NET_1322 P33 l=0.300u w=30.000u
M92 NET_6156 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M93 VDD33 NET_3552 NET_6154 NET_1322 P33 l=0.300u w=30.000u
M94 NET_6154 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M95 PAD NET_40 NET_6162 NET_1322 P33 l=0.300u w=30.000u
M96 NET_6162 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M97 VDD33 NET_3552 NET_6160 NET_1322 P33 l=0.300u w=30.000u
M98 NET_6160 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M99 NET_6146 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M100 NET_6146 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M101 VDD33 NET_3552 NET_6144 NET_1322 P33 l=0.300u w=30.000u
M102 NET_6144 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M103 PAD NET_40 NET_6133 NET_1322 P33 l=0.300u w=30.000u
M104 NET_6149 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M105 NET_6149 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M106 VDD33 NET_3552 NET_6147 NET_1322 P33 l=0.300u w=30.000u
M107 NET_6147 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M108 PAD NET_40 NET_6139 NET_1322 P33 l=0.300u w=30.000u
M109 VDD33 VSS NET_3552 VDD33 P33 l=0.300u w=5.000u
M110 VDD33 NET_3552 NET_6131 NET_1322 P33 l=0.300u w=30.000u
M111 NET_6131 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M112 PAD NET_40 NET_6129 NET_1322 P33 l=0.300u w=30.000u
M113 NET_6129 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M114 VDD33 NET_3552 NET_6137 NET_1322 P33 l=0.300u w=30.000u
M115 NET_6137 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M116 PAD NET_40 NET_6135 NET_1322 P33 l=0.300u w=30.000u
M117 NET_6135 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M118 NET_1322 PAD VDD33 NET_1322 P33 l=0.350u w=5.000u
M119 NET_1322 PAD VDD33 NET_1322 P33 l=0.350u w=5.000u
M120 VDD33 PAD NET_1322 NET_1322 P33 l=0.350u w=5.000u
M121 PAD VDD33 NET_40 NET_1322 P33 l=0.350u w=10.000u
M122 VDD33 VDD NET_44 NET_1322 P33 l=1.070u w=5.000u
M123 PAD VDD33 NET_1322 NET_1322 P33 l=0.350u w=15.000u
M124 NET_6186 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M125 NET_6133 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M126 NET_6188 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M127 NET_6139 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
R1 PAD NET_44 300.135
.ends PISU

.subckt PIS   PAD C FP
M1 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M3 C NET_57 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M5 C NET_57 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_60 NET_57 VSS N18 l=0.180u w=2.000u
M8 VSS NET_60 NET_57 VSS N18 l=0.180u w=2.000u
M9 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M10 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M11 C NET_57 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M13 C NET_57 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M15 VDD NET_60 NET_57 VDD P18 l=0.180u w=5.000u
M16 VDD NET_60 NET_57 VDD P18 l=0.180u w=5.000u
M17 NET_64 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M18 NET_64 FP PAD VSSD N33 l=0.400u w=28.000u
M19 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M20 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M21 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M22 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M23 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M24 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M25 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M26 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M27 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M28 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M29 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M30 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M31 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M32 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M33 NET_66 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M34 NET_66 FP PAD VSSD N33 l=0.400u w=28.000u
M35 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M36 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M38 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M39 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M40 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M42 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M43 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M46 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M47 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M48 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M49 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M50 NET_42 NET_3552 NET_40 VSS N33 l=0.350u w=8.000u
M51 NET_42 VSS VSS VSS N33 l=0.350u w=8.000u
M52 NET_44 VDD33 NET_43 VSS N33 l=0.350u w=8.000u
M53 NET_44 VDD33 NET_43 VSS N33 l=0.350u w=8.000u
M54 NET_43 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M55 NET_8 NET_43 NET_47 VSS N33 l=0.350u w=8.000u
M56 NET_8 NET_43 VSS VSS N33 l=0.350u w=8.000u
M57 NET_8 NET_47 VDD33 VSS N33 l=0.350u w=0.820u
M58 VSS NET_47 NET_60 VSS N33 l=0.350u w=2.000u
M59 VSS NET_47 NET_60 VSS N33 l=0.350u w=2.000u
M60 NET_6232 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M61 NET_6234 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M62 VSS NET_47 NET_3652 VDD33 P33 l=0.300u w=5.100u
M63 NET_6218 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M64 NET_6218 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M65 VDD33 NET_3552 NET_6216 NET_1322 P33 l=0.300u w=30.000u
M66 NET_6216 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M67 NET_6223 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M68 NET_6223 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M69 VDD33 NET_3552 NET_6221 NET_1322 P33 l=0.300u w=30.000u
M70 NET_6221 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M71 NET_47 NET_43 NET_3652 VDD33 P33 l=0.300u w=5.000u
M72 VSS NET_47 NET_3652 VDD33 P33 l=0.300u w=5.100u
M73 VSS NET_47 NET_3652 VDD33 P33 l=0.300u w=5.100u
M74 VSS NET_47 NET_3652 VDD33 P33 l=0.300u w=5.100u
M75 NET_60 NET_47 VDD VDD P33 l=0.300u w=5.000u
M76 NET_60 NET_47 VDD VDD P33 l=0.300u w=5.000u
M77 VDD NET_47 NET_60 VDD P33 l=0.300u w=5.000u
M78 NET_60 NET_47 VDD VDD P33 l=0.300u w=5.000u
M79 VDD NET_47 NET_60 VDD P33 l=0.300u w=5.000u
M80 PAD NET_40 NET_6214 NET_1322 P33 l=0.300u w=30.000u
M81 NET_6214 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M82 VDD33 NET_3552 NET_6206 NET_1322 P33 l=0.300u w=30.000u
M83 NET_6206 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M84 PAD NET_40 NET_6219 NET_1322 P33 l=0.300u w=30.000u
M85 NET_6219 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M86 VDD33 NET_3552 NET_6212 NET_1322 P33 l=0.300u w=30.000u
M87 NET_6212 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M88 NET_47 NET_43 NET_3652 VDD33 P33 l=0.300u w=5.000u
M89 NET_3652 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M90 VDD33 NET_44 NET_3652 VDD33 P33 l=0.300u w=5.000u
M91 PAD NET_40 NET_6204 NET_1322 P33 l=0.300u w=30.000u
M92 NET_6204 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M93 VDD33 NET_3552 NET_6202 NET_1322 P33 l=0.300u w=30.000u
M94 NET_6202 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M95 PAD NET_40 NET_6210 NET_1322 P33 l=0.300u w=30.000u
M96 NET_6210 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M97 VDD33 NET_3552 NET_6208 NET_1322 P33 l=0.300u w=30.000u
M98 NET_6208 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M99 NET_6194 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M100 NET_6194 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M101 VDD33 NET_3552 NET_6192 NET_1322 P33 l=0.300u w=30.000u
M102 NET_6192 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M103 PAD NET_40 NET_6181 NET_1322 P33 l=0.300u w=30.000u
M104 NET_6197 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M105 NET_6197 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M106 VDD33 NET_3552 NET_6195 NET_1322 P33 l=0.300u w=30.000u
M107 NET_6195 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M108 PAD NET_40 NET_6187 NET_1322 P33 l=0.300u w=30.000u
M109 VDD33 VSS NET_3552 VDD33 P33 l=0.300u w=5.000u
M110 VDD33 NET_3552 NET_6179 NET_1322 P33 l=0.300u w=30.000u
M111 NET_6179 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M112 PAD NET_40 NET_6177 NET_1322 P33 l=0.300u w=30.000u
M113 NET_6177 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M114 VDD33 NET_3552 NET_6185 NET_1322 P33 l=0.300u w=30.000u
M115 NET_6185 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M116 PAD NET_40 NET_6183 NET_1322 P33 l=0.300u w=30.000u
M117 NET_6183 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M118 NET_1322 PAD VDD33 NET_1322 P33 l=0.350u w=5.000u
M119 NET_1322 PAD VDD33 NET_1322 P33 l=0.350u w=5.000u
M120 VDD33 PAD NET_1322 NET_1322 P33 l=0.350u w=5.000u
M121 PAD VDD33 NET_1322 NET_1322 P33 l=0.350u w=15.000u
M122 NET_6232 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M123 NET_6181 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M124 NET_6234 NET_40 PAD NET_1322 P33 l=0.300u w=30.000u
M125 NET_6187 NET_3552 VDD33 NET_1322 P33 l=0.300u w=30.000u
M126 PAD VDD33 NET_40 NET_1322 P33 l=0.350u w=10.000u
M127 NET_1322 NET_1322 NET_1322 NET_1322 P33 l=1.070u w=5.000u
R1 PAD NET_44 300.135
.ends PIS

.subckt PID   PAD C FP
M1 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M3 C NET_57 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M5 C NET_57 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_57 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_60 NET_57 VSS N18 l=0.180u w=2.000u
M8 VSS NET_60 NET_57 VSS N18 l=0.180u w=2.000u
M9 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M10 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M11 C NET_57 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M13 C NET_57 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_57 C VDD P18 l=0.180u w=5.000u
M15 VDD NET_60 NET_57 VDD P18 l=0.180u w=5.000u
M16 VDD NET_60 NET_57 VDD P18 l=0.180u w=5.000u
M17 NET_65 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M18 NET_65 FP PAD VSSD N33 l=0.400u w=28.000u
M19 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M20 NET_35 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M21 VSSD NET_23 NET_33 VSSD N33 l=0.400u w=28.000u
M22 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M23 PAD FP NET_31 VSSD N33 l=0.400u w=28.000u
M24 NET_31 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M25 VSSD NET_23 NET_29 VSSD N33 l=0.400u w=28.000u
M26 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M27 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M28 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M29 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M30 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M31 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M32 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M33 NET_67 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M34 NET_67 FP PAD VSSD N33 l=0.400u w=28.000u
M35 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M36 NET_42 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_23 NET_40 VSSD N33 l=0.400u w=28.000u
M38 NET_40 FP PAD VSSD N33 l=0.400u w=28.000u
M39 PAD FP NET_38 VSSD N33 l=0.400u w=28.000u
M40 NET_38 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_23 NET_36 VSSD N33 l=0.400u w=28.000u
M42 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M43 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M46 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M47 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M48 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M49 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M50 NET_45 VDD33 NET_28 VSS N33 l=0.350u w=8.000u
M51 NET_45 VDD33 NET_28 VSS N33 l=0.350u w=8.000u
M52 NET_28 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M53 VSS NET_28 NET_48 VSS N33 l=0.350u w=8.000u
M54 NET_28 VDD33 VSS VSS N33 l=4.550u w=0.800u
M55 VSS NET_48 NET_60 VSS N33 l=0.350u w=2.000u
M56 VSS NET_48 NET_60 VSS N33 l=0.350u w=2.000u
M57 NET_26 NET_3551 NET_24 VSS N33 l=0.350u w=8.000u
M58 NET_26 VSS VSS VSS N33 l=0.350u w=8.000u
M59 NET_6272 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M60 NET_6274 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M61 VDD NET_48 NET_60 VDD P33 l=0.300u w=5.000u
M62 VDD NET_48 NET_60 VDD P33 l=0.300u w=5.000u
M63 NET_6256 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M64 NET_6256 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M65 VDD33 NET_3551 NET_6254 NET_1321 P33 l=0.300u w=30.000u
M66 NET_6254 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M67 NET_6261 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M68 NET_6261 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M69 VDD33 NET_3551 NET_6259 NET_1321 P33 l=0.300u w=30.000u
M70 NET_6259 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M71 NET_48 NET_28 NET_3651 VDD33 P33 l=0.300u w=5.000u
M72 NET_48 NET_28 NET_3651 VDD33 P33 l=0.300u w=5.000u
M73 NET_3651 NET_28 NET_48 VDD33 P33 l=0.300u w=5.000u
M74 NET_48 NET_28 NET_3651 VDD33 P33 l=0.300u w=5.000u
M75 NET_3651 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M76 NET_60 NET_48 VDD VDD P33 l=0.300u w=5.000u
M77 VDD NET_48 NET_60 VDD P33 l=0.300u w=5.000u
M78 NET_60 NET_48 VDD VDD P33 l=0.300u w=5.000u
M79 VDD NET_48 NET_60 VDD P33 l=0.300u w=5.000u
M80 NET_60 NET_48 VDD VDD P33 l=0.300u w=5.000u
M81 VDD NET_48 NET_60 VDD P33 l=0.300u w=5.000u
M82 PAD NET_24 NET_6252 NET_1321 P33 l=0.300u w=30.000u
M83 NET_6252 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M84 VDD33 NET_3551 NET_6244 NET_1321 P33 l=0.300u w=30.000u
M85 NET_6244 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M86 PAD NET_24 NET_6257 NET_1321 P33 l=0.300u w=30.000u
M87 NET_6257 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M88 VDD33 NET_3551 NET_6250 NET_1321 P33 l=0.300u w=30.000u
M89 NET_6250 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M90 VDD33 NET_45 NET_3651 VDD33 P33 l=0.300u w=5.000u
M91 NET_3651 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M92 VDD33 NET_45 NET_3651 VDD33 P33 l=0.300u w=5.000u
M93 PAD NET_24 NET_6242 NET_1321 P33 l=0.300u w=30.000u
M94 NET_6242 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M95 VDD33 NET_3551 NET_6240 NET_1321 P33 l=0.300u w=30.000u
M96 NET_6240 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M97 PAD NET_24 NET_6248 NET_1321 P33 l=0.300u w=30.000u
M98 NET_6248 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M99 VDD33 NET_3551 NET_6246 NET_1321 P33 l=0.300u w=30.000u
M100 NET_6246 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M101 NET_6232 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M102 NET_6232 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M103 VDD33 NET_3551 NET_6230 NET_1321 P33 l=0.300u w=30.000u
M104 NET_6230 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M105 PAD NET_24 NET_6219 NET_1321 P33 l=0.300u w=30.000u
M106 NET_6235 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M107 NET_6235 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M108 VDD33 NET_3551 NET_6233 NET_1321 P33 l=0.300u w=30.000u
M109 NET_6233 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M110 PAD NET_24 NET_6225 NET_1321 P33 l=0.300u w=30.000u
M111 VDD33 VSS NET_3551 VDD33 P33 l=0.300u w=5.000u
M112 VDD33 NET_3551 NET_6217 NET_1321 P33 l=0.300u w=30.000u
M113 NET_6217 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M114 PAD NET_24 NET_6215 NET_1321 P33 l=0.300u w=30.000u
M115 NET_6215 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M116 VDD33 NET_3551 NET_6223 NET_1321 P33 l=0.300u w=30.000u
M117 NET_6223 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M118 PAD NET_24 NET_6221 NET_1321 P33 l=0.300u w=30.000u
M119 NET_6221 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M120 NET_1321 PAD VDD33 NET_1321 P33 l=0.350u w=5.000u
M121 NET_1321 PAD VDD33 NET_1321 P33 l=0.350u w=5.000u
M122 VDD33 PAD NET_1321 NET_1321 P33 l=0.350u w=5.000u
M123 PAD VDD33 NET_1321 NET_1321 P33 l=0.350u w=15.000u
M124 NET_6272 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M125 NET_6219 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M126 NET_6274 NET_24 PAD NET_1321 P33 l=0.300u w=30.000u
M127 NET_6225 NET_3551 VDD33 NET_1321 P33 l=0.300u w=30.000u
M128 PAD VDD33 NET_24 NET_1321 P33 l=0.350u w=10.000u
M129 NET_1321 NET_1321 NET_1321 NET_1321 P33 l=1.070u w=5.000u
R1 PAD NET_45 300.135
.ends PID

.subckt PICU   PAD C REN FP
M1 VSS NET_64 NET_42 VSS N18 l=0.180u w=2.000u
M2 VSS NET_64 NET_42 VSS N18 l=0.180u w=2.000u
M3 VSS REN NET_54 VSS N18 l=0.180u w=2.000u
M4 VSS REN NET_54 VSS N18 l=0.180u w=2.000u
M5 VSS NET_42 C VSS N18 l=0.180u w=2.000u
M6 VSS NET_42 C VSS N18 l=0.180u w=2.000u
M7 C NET_42 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_42 C VSS N18 l=0.180u w=2.000u
M9 C NET_42 VSS VSS N18 l=0.180u w=2.000u
M10 VSS NET_42 C VSS N18 l=0.180u w=2.000u
M11 VDD NET_42 C VDD P18 l=0.180u w=5.000u
M12 VDD NET_42 C VDD P18 l=0.180u w=5.000u
M13 C NET_42 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_42 C VDD P18 l=0.180u w=5.000u
M15 C NET_42 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_42 C VDD P18 l=0.180u w=5.000u
M17 VDD NET_64 NET_42 VDD P18 l=0.180u w=5.000u
M18 VDD NET_64 NET_42 VDD P18 l=0.180u w=5.000u
M19 VDD REN NET_54 VDD P18 l=0.180u w=5.000u
M20 VDD REN NET_54 VDD P18 l=0.180u w=5.000u
M21 NET_71 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M22 NET_71 FP PAD VSSD N33 l=0.400u w=28.000u
M23 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M24 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M25 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M26 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M27 PAD FP NET_29 VSSD N33 l=0.400u w=28.000u
M28 NET_29 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M29 VSSD NET_23 NET_27 VSSD N33 l=0.400u w=28.000u
M30 NET_27 FP PAD VSSD N33 l=0.400u w=28.000u
M31 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M32 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M33 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M34 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M35 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M36 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M37 NET_73 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M38 NET_73 FP PAD VSSD N33 l=0.400u w=28.000u
M39 NET_40 FP PAD VSSD N33 l=0.400u w=28.000u
M40 NET_40 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_23 NET_38 VSSD N33 l=0.400u w=28.000u
M42 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M43 PAD FP NET_36 VSSD N33 l=0.400u w=28.000u
M44 NET_36 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_23 NET_34 VSSD N33 l=0.400u w=28.000u
M46 NET_34 FP PAD VSSD N33 l=0.400u w=28.000u
M47 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M50 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M51 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M52 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M53 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M54 NET_46 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M55 NET_46 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M56 NET_45 VDD33 NET_46 VSS N33 l=0.350u w=8.000u
M57 VSS REN NET_49 VSS N33 l=0.350u w=8.000u
M58 VSS NET_54 NET_50 VSS N33 l=0.350u w=8.000u
M59 VSS NET_45 NET_52 VSS N33 l=0.350u w=8.000u
M60 NET_75 NET_49 VDD VSS N33 l=0.350u w=4.000u
M61 VSS NET_52 NET_64 VSS N33 l=0.350u w=2.000u
M62 VSS NET_52 NET_64 VSS N33 l=0.350u w=2.000u
M63 NET_26 NET_3558 NET_24 VSS N33 l=0.350u w=8.000u
M64 NET_26 VSS VSS VSS N33 l=0.350u w=8.000u
M65 VDD33 NET_3558 NET_6205 NET_1328 P33 l=0.300u w=30.000u
M66 VDD33 NET_3558 NET_6206 NET_1328 P33 l=0.300u w=30.000u
M67 NET_75 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M68 NET_64 NET_52 VDD VDD P33 l=0.300u w=5.000u
M69 NET_64 NET_52 VDD VDD P33 l=0.300u w=5.000u
M70 NET_6188 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M71 NET_6188 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M72 VDD33 NET_3558 NET_6186 NET_1328 P33 l=0.300u w=30.000u
M73 NET_6186 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M74 NET_6193 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M75 NET_6193 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M76 VDD33 NET_3558 NET_6191 NET_1328 P33 l=0.300u w=30.000u
M77 NET_6191 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M78 NET_52 NET_45 NET_3635 VDD33 P33 l=0.300u w=5.000u
M79 NET_52 NET_45 NET_3635 VDD33 P33 l=0.300u w=5.000u
M80 NET_3635 NET_45 NET_52 VDD33 P33 l=0.300u w=5.000u
M81 NET_52 NET_45 NET_3635 VDD33 P33 l=0.300u w=5.000u
M82 NET_3635 NET_46 VDD33 VDD33 P33 l=0.300u w=5.000u
M83 NET_64 NET_52 VDD VDD P33 l=0.300u w=5.000u
M84 VDD NET_52 NET_64 VDD P33 l=0.300u w=5.000u
M85 NET_64 NET_52 VDD VDD P33 l=0.300u w=5.000u
M86 VDD NET_52 NET_64 VDD P33 l=0.300u w=5.000u
M87 NET_64 NET_52 VDD VDD P33 l=0.300u w=5.000u
M88 VDD NET_52 NET_64 VDD P33 l=0.300u w=5.000u
M89 PAD NET_24 NET_6184 NET_1328 P33 l=0.300u w=30.000u
M90 NET_6184 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M91 VDD33 NET_3558 NET_6174 NET_1328 P33 l=0.300u w=30.000u
M92 NET_6174 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M93 PAD NET_24 NET_6189 NET_1328 P33 l=0.300u w=30.000u
M94 NET_6189 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M95 VDD33 NET_3558 NET_6179 NET_1328 P33 l=0.300u w=30.000u
M96 NET_6179 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M97 VDD33 NET_46 NET_3635 VDD33 P33 l=0.300u w=5.000u
M98 NET_3635 NET_46 VDD33 VDD33 P33 l=0.300u w=5.000u
M99 VDD33 NET_46 NET_3635 VDD33 P33 l=0.300u w=5.000u
M100 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M101 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M102 PAD NET_24 NET_6172 NET_1328 P33 l=0.300u w=30.000u
M103 NET_6172 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M104 VDD33 NET_3558 NET_6169 NET_1328 P33 l=0.300u w=30.000u
M105 NET_6169 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M106 PAD NET_24 NET_6177 NET_1328 P33 l=0.300u w=30.000u
M107 NET_6177 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M108 VDD33 NET_3558 NET_6170 NET_1328 P33 l=0.300u w=30.000u
M109 NET_6170 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M110 NET_6161 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M111 NET_6161 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M112 VDD33 NET_3558 NET_6159 NET_1328 P33 l=0.300u w=30.000u
M113 NET_6159 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M114 PAD NET_24 NET_6152 NET_1328 P33 l=0.300u w=30.000u
M115 NET_6164 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M116 NET_6164 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M117 VDD33 NET_3558 NET_6162 NET_1328 P33 l=0.300u w=30.000u
M118 NET_6162 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M119 PAD NET_24 NET_6158 NET_1328 P33 l=0.300u w=30.000u
M120 VDD33 VSS NET_3558 VDD33 P33 l=0.300u w=5.000u
M121 NET_1328 PAD VDD33 NET_1328 P33 l=0.350u w=5.000u
M122 NET_1328 PAD VDD33 NET_1328 P33 l=0.350u w=5.000u
M123 VDD33 PAD NET_1328 NET_1328 P33 l=0.350u w=5.000u
M124 VDD33 NET_3558 NET_6150 NET_1328 P33 l=0.300u w=30.000u
M125 NET_6150 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M126 PAD NET_24 NET_6148 NET_1328 P33 l=0.300u w=30.000u
M127 NET_6148 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M128 VDD33 NET_3558 NET_6156 NET_1328 P33 l=0.300u w=30.000u
M129 NET_6156 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M130 PAD NET_24 NET_6154 NET_1328 P33 l=0.300u w=30.000u
M131 NET_6154 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M132 PAD VDD33 NET_24 NET_1328 P33 l=0.350u w=10.000u
M133 NET_46 NET_75 VDD33 NET_1328 P33 l=1.070u w=5.000u
M134 PAD VDD33 NET_1328 NET_1328 P33 l=0.350u w=15.000u
M135 NET_6205 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M136 NET_6152 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M137 NET_6206 NET_24 PAD NET_1328 P33 l=0.300u w=30.000u
M138 NET_6158 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
R1 PAD NET_46 300.135
.ends PICU

.subckt PICD   PAD C REN FP
M1 VSS NET_66 NET_44 VSS N18 l=0.180u w=2.000u
M2 VSS NET_66 NET_44 VSS N18 l=0.180u w=2.000u
M3 VSS REN NET_56 VSS N18 l=0.180u w=2.000u
M4 VSS REN NET_56 VSS N18 l=0.180u w=2.000u
M5 VSS NET_44 C VSS N18 l=0.180u w=2.000u
M6 VSS NET_44 C VSS N18 l=0.180u w=2.000u
M7 C NET_44 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_44 C VSS N18 l=0.180u w=2.000u
M9 C NET_44 VSS VSS N18 l=0.180u w=2.000u
M10 VSS NET_44 C VSS N18 l=0.180u w=2.000u
M11 VDD NET_44 C VDD P18 l=0.180u w=5.000u
M12 VDD NET_44 C VDD P18 l=0.180u w=5.000u
M13 C NET_44 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_44 C VDD P18 l=0.180u w=5.000u
M15 C NET_44 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_44 C VDD P18 l=0.180u w=5.000u
M17 VDD NET_66 NET_44 VDD P18 l=0.180u w=5.000u
M18 VDD NET_66 NET_44 VDD P18 l=0.180u w=5.000u
M19 VDD REN NET_56 VDD P18 l=0.180u w=5.000u
M20 VDD REN NET_56 VDD P18 l=0.180u w=5.000u
M21 NET_72 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M22 NET_72 FP PAD VSSD N33 l=0.400u w=28.000u
M23 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M24 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M25 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M26 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M27 PAD FP NET_31 VSSD N33 l=0.400u w=28.000u
M28 NET_31 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M29 VSSD NET_25 NET_29 VSSD N33 l=0.400u w=28.000u
M30 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M31 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M32 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M33 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M34 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M35 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M36 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M37 NET_74 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M38 NET_74 FP PAD VSSD N33 l=0.400u w=28.000u
M39 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M40 NET_42 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_25 NET_40 VSSD N33 l=0.400u w=28.000u
M42 NET_40 FP PAD VSSD N33 l=0.400u w=28.000u
M43 PAD FP NET_38 VSSD N33 l=0.400u w=28.000u
M44 NET_38 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_25 NET_36 VSSD N33 l=0.400u w=28.000u
M46 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M47 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M50 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M51 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M52 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M53 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M54 NET_48 VDD33 NET_11 VSS N33 l=0.350u w=8.000u
M55 NET_48 VDD33 NET_11 VSS N33 l=0.350u w=8.000u
M56 NET_11 VDD33 NET_48 VSS N33 l=0.350u w=8.000u
M57 VSS REN NET_51 VSS N33 l=0.350u w=8.000u
M58 VSS NET_56 NET_52 VSS N33 l=0.350u w=8.000u
M59 VSS NET_11 NET_54 VSS N33 l=0.350u w=8.000u
M60 NET_11 NET_51 VSS VSS N33 l=4.550u w=0.800u
M61 VSS NET_54 NET_66 VSS N33 l=0.350u w=2.000u
M62 VSS NET_54 NET_66 VSS N33 l=0.350u w=2.000u
M63 NET_28 NET_3558 NET_26 VSS N33 l=0.350u w=8.000u
M64 NET_28 VSS VSS VSS N33 l=0.350u w=8.000u
M65 VDD33 NET_3558 NET_6269 NET_1328 P33 l=0.300u w=30.000u
M66 VDD33 NET_3558 NET_6270 NET_1328 P33 l=0.300u w=30.000u
M67 NET_66 NET_54 VDD VDD P33 l=0.300u w=5.000u
M68 NET_66 NET_54 VDD VDD P33 l=0.300u w=5.000u
M69 NET_6253 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M70 NET_6253 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M71 VDD33 NET_3558 NET_6251 NET_1328 P33 l=0.300u w=30.000u
M72 NET_6251 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M73 NET_6258 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M74 NET_6258 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M75 VDD33 NET_3558 NET_6256 NET_1328 P33 l=0.300u w=30.000u
M76 NET_6256 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M77 NET_54 NET_11 NET_3635 VDD33 P33 l=0.300u w=5.000u
M78 NET_54 NET_11 NET_3635 VDD33 P33 l=0.300u w=5.000u
M79 NET_3635 NET_11 NET_54 VDD33 P33 l=0.300u w=5.000u
M80 NET_54 NET_11 NET_3635 VDD33 P33 l=0.300u w=5.000u
M81 NET_3635 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M82 NET_66 NET_54 VDD VDD P33 l=0.300u w=5.000u
M83 VDD NET_54 NET_66 VDD P33 l=0.300u w=5.000u
M84 NET_66 NET_54 VDD VDD P33 l=0.300u w=5.000u
M85 VDD NET_54 NET_66 VDD P33 l=0.300u w=5.000u
M86 NET_66 NET_54 VDD VDD P33 l=0.300u w=5.000u
M87 VDD NET_54 NET_66 VDD P33 l=0.300u w=5.000u
M88 PAD NET_26 NET_6249 NET_1328 P33 l=0.300u w=30.000u
M89 NET_6249 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M90 VDD33 NET_3558 NET_6239 NET_1328 P33 l=0.300u w=30.000u
M91 NET_6239 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M92 PAD NET_26 NET_6254 NET_1328 P33 l=0.300u w=30.000u
M93 NET_6254 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M94 VDD33 NET_3558 NET_6244 NET_1328 P33 l=0.300u w=30.000u
M95 NET_6244 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M96 VDD33 NET_48 NET_3635 VDD33 P33 l=0.300u w=5.000u
M97 NET_3635 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M98 VDD33 NET_48 NET_3635 VDD33 P33 l=0.300u w=5.000u
M99 VDD33 NET_51 NET_52 VDD33 P33 l=0.300u w=5.000u
M100 VDD33 NET_52 NET_51 VDD33 P33 l=0.300u w=5.000u
M101 PAD NET_26 NET_6237 NET_1328 P33 l=0.300u w=30.000u
M102 NET_6237 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M103 VDD33 NET_3558 NET_6234 NET_1328 P33 l=0.300u w=30.000u
M104 NET_6234 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M105 PAD NET_26 NET_6242 NET_1328 P33 l=0.300u w=30.000u
M106 NET_6242 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M107 VDD33 NET_3558 NET_6235 NET_1328 P33 l=0.300u w=30.000u
M108 NET_6235 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M109 NET_6226 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M110 NET_6226 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M111 VDD33 NET_3558 NET_6224 NET_1328 P33 l=0.300u w=30.000u
M112 NET_6224 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M113 PAD NET_26 NET_6213 NET_1328 P33 l=0.300u w=30.000u
M114 NET_6229 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M115 NET_6229 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M116 VDD33 NET_3558 NET_6227 NET_1328 P33 l=0.300u w=30.000u
M117 NET_6227 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M118 PAD NET_26 NET_6219 NET_1328 P33 l=0.300u w=30.000u
M119 VDD33 VSS NET_3558 VDD33 P33 l=0.300u w=5.000u
M120 VDD33 NET_3558 NET_6211 NET_1328 P33 l=0.300u w=30.000u
M121 NET_6211 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M122 PAD NET_26 NET_6209 NET_1328 P33 l=0.300u w=30.000u
M123 NET_6209 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M124 VDD33 NET_3558 NET_6217 NET_1328 P33 l=0.300u w=30.000u
M125 NET_6217 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M126 PAD NET_26 NET_6215 NET_1328 P33 l=0.300u w=30.000u
M127 NET_6215 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M128 NET_1328 PAD VDD33 NET_1328 P33 l=0.350u w=5.000u
M129 NET_1328 PAD VDD33 NET_1328 P33 l=0.350u w=5.000u
M130 VDD33 PAD NET_1328 NET_1328 P33 l=0.350u w=5.000u
M131 PAD VDD33 NET_26 NET_1328 P33 l=0.350u w=10.000u
M132 NET_1328 NET_1328 NET_1328 NET_1328 P33 l=1.070u w=5.000u
M133 PAD VDD33 NET_1328 NET_1328 P33 l=0.350u w=15.000u
M134 NET_6269 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M135 NET_6213 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
M136 NET_6270 NET_26 PAD NET_1328 P33 l=0.300u w=30.000u
M137 NET_6219 NET_3558 VDD33 NET_1328 P33 l=0.300u w=30.000u
R1 PAD NET_48 300.135
.ends PICD

.subckt PI   PAD C FP
M1 VSS NET_60 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_60 C VSS N18 l=0.180u w=2.000u
M3 C NET_60 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_60 C VSS N18 l=0.180u w=2.000u
M5 C NET_60 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_60 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_63 NET_60 VSS N18 l=0.180u w=2.000u
M8 VSS NET_63 NET_60 VSS N18 l=0.180u w=2.000u
M9 VDD NET_60 C VDD P18 l=0.180u w=5.000u
M10 VDD NET_60 C VDD P18 l=0.180u w=5.000u
M11 C NET_60 VDD VDD P18 l=0.180u w=5.000u
M12 VDD NET_60 C VDD P18 l=0.180u w=5.000u
M13 C NET_60 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_60 C VDD P18 l=0.180u w=5.000u
M15 VDD NET_63 NET_60 VDD P18 l=0.180u w=5.000u
M16 VDD NET_63 NET_60 VDD P18 l=0.180u w=5.000u
M17 NET_46 NET_3537 NET_44 VSS N33 l=0.350u w=8.000u
M18 NET_46 VSS VSS VSS N33 l=0.350u w=8.000u
M19 NET_43 VDD33 NET_47 VSS N33 l=0.350u w=8.000u
M20 NET_43 VDD33 NET_47 VSS N33 l=0.350u w=8.000u
M21 NET_47 VDD33 NET_43 VSS N33 l=0.350u w=8.000u
M22 VSS NET_47 NET_51 VSS N33 l=0.350u w=8.000u
M23 VSS NET_51 NET_63 VSS N33 l=0.350u w=2.000u
M24 VSS NET_51 NET_63 VSS N33 l=0.350u w=2.000u
M25 NET_40 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M26 NET_40 FP PAD VSSD N33 l=0.400u w=28.000u
M27 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M28 NET_30 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M29 VSSD NET_23 NET_28 VSSD N33 l=0.400u w=28.000u
M30 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M31 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M32 NET_26 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M33 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M34 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M35 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M36 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M38 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M39 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M40 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M41 NET_42 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M42 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M43 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_37 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_23 NET_35 VSSD N33 l=0.400u w=28.000u
M46 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M47 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M48 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M50 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M54 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M56 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M57 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M58 VDD NET_51 NET_63 VDD P33 l=0.300u w=5.000u
M59 VDD NET_51 NET_63 VDD P33 l=0.300u w=5.000u
M60 NET_6268 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M61 NET_6270 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M62 NET_63 NET_51 VDD VDD P33 l=0.300u w=5.000u
M63 VDD NET_51 NET_63 VDD P33 l=0.300u w=5.000u
M64 NET_63 NET_51 VDD VDD P33 l=0.300u w=5.000u
M65 VDD NET_51 NET_63 VDD P33 l=0.300u w=5.000u
M66 NET_63 NET_51 VDD VDD P33 l=0.300u w=5.000u
M67 VDD NET_51 NET_63 VDD P33 l=0.300u w=5.000u
M68 NET_6252 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M69 NET_6252 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M70 VDD33 NET_3537 NET_6250 NET_1319 P33 l=0.300u w=30.000u
M71 NET_6250 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M72 NET_6257 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M73 NET_6257 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M74 VDD33 NET_3537 NET_6255 NET_1319 P33 l=0.300u w=30.000u
M75 NET_6255 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M76 NET_51 NET_47 NET_3649 VDD33 P33 l=0.300u w=5.000u
M77 NET_51 NET_47 NET_3649 VDD33 P33 l=0.300u w=5.000u
M78 NET_3649 NET_47 NET_51 VDD33 P33 l=0.300u w=5.000u
M79 NET_51 NET_47 NET_3649 VDD33 P33 l=0.300u w=5.000u
M80 NET_3649 NET_43 VDD33 VDD33 P33 l=0.300u w=5.000u
M81 PAD NET_44 NET_6248 NET_1319 P33 l=0.300u w=30.000u
M82 NET_6248 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M83 VDD33 NET_3537 NET_6240 NET_1319 P33 l=0.300u w=30.000u
M84 NET_6240 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M85 PAD NET_44 NET_6253 NET_1319 P33 l=0.300u w=30.000u
M86 NET_6253 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M87 VDD33 NET_3537 NET_6246 NET_1319 P33 l=0.300u w=30.000u
M88 NET_6246 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M89 VDD33 NET_43 NET_3649 VDD33 P33 l=0.300u w=5.000u
M90 NET_3649 NET_43 VDD33 VDD33 P33 l=0.300u w=5.000u
M91 VDD33 NET_43 NET_3649 VDD33 P33 l=0.300u w=5.000u
M92 PAD NET_44 NET_6238 NET_1319 P33 l=0.300u w=30.000u
M93 NET_6238 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M94 VDD33 NET_3537 NET_6236 NET_1319 P33 l=0.300u w=30.000u
M95 NET_6236 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M96 PAD NET_44 NET_6244 NET_1319 P33 l=0.300u w=30.000u
M97 NET_6244 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M98 VDD33 NET_3537 NET_6242 NET_1319 P33 l=0.300u w=30.000u
M99 NET_6242 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M100 NET_6228 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M101 NET_6228 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M102 VDD33 NET_3537 NET_6226 NET_1319 P33 l=0.300u w=30.000u
M103 NET_6226 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M104 PAD NET_44 NET_6215 NET_1319 P33 l=0.300u w=30.000u
M105 NET_6231 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M106 NET_6231 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M107 VDD33 NET_3537 NET_6229 NET_1319 P33 l=0.300u w=30.000u
M108 NET_6229 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M109 PAD NET_44 NET_6221 NET_1319 P33 l=0.300u w=30.000u
M110 VDD33 VSS NET_3537 VDD33 P33 l=0.300u w=5.000u
M111 VDD33 NET_3537 NET_6213 NET_1319 P33 l=0.300u w=30.000u
M112 NET_6213 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M113 PAD NET_44 NET_6211 NET_1319 P33 l=0.300u w=30.000u
M114 NET_6211 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M115 VDD33 NET_3537 NET_6219 NET_1319 P33 l=0.300u w=30.000u
M116 NET_6219 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M117 PAD NET_44 NET_6217 NET_1319 P33 l=0.300u w=30.000u
M118 NET_6217 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M119 NET_1319 PAD VDD33 NET_1319 P33 l=0.350u w=5.000u
M120 NET_1319 PAD VDD33 NET_1319 P33 l=0.350u w=5.000u
M121 VDD33 PAD NET_1319 NET_1319 P33 l=0.350u w=5.000u
M122 PAD VDD33 NET_1319 NET_1319 P33 l=0.350u w=15.000u
M123 NET_6268 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M124 NET_6215 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M125 NET_6270 NET_44 PAD NET_1319 P33 l=0.300u w=30.000u
M126 NET_6221 NET_3537 VDD33 NET_1319 P33 l=0.300u w=30.000u
M127 NET_1319 NET_1319 NET_1319 NET_1319 P33 l=1.070u w=5.000u
M128 PAD VDD33 NET_44 NET_1319 P33 l=0.350u w=10.000u
R1 PAD NET_43 300.135
.ends PI

.subckt POTL8   PAD OEN I FP
M1 VSS NET_65 NET_61 VSS N18 l=0.180u w=4.000u
M2 VSS NET_65 NET_61 VSS N18 l=0.180u w=4.000u
M3 NET_66 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_66 NET_67 NET_65 VSS N18 l=0.180u w=4.000u
M5 VSS OEN NET_67 VSS N18 l=0.180u w=2.000u
M6 VSS OEN NET_67 VSS N18 l=0.180u w=2.000u
M7 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M8 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M9 NET_70 I VSS VSS N18 l=0.180u w=2.000u
M10 VSS I NET_70 VSS N18 l=0.180u w=2.000u
M11 VSS NET_70 NET_43 VSS N18 l=0.180u w=2.000u
M12 VSS NET_70 NET_43 VSS N18 l=0.180u w=2.000u
M13 NET_6237 OEN NET_70 VDD P18 l=0.180u w=5.000u
M14 NET_6237 I VDD VDD P18 l=0.180u w=5.000u
M15 VDD NET_70 NET_43 VDD P18 l=0.180u w=5.000u
M16 VDD NET_70 NET_43 VDD P18 l=0.180u w=5.000u
M17 NET_43 NET_70 VDD VDD P18 l=0.180u w=5.000u
M18 VDD NET_70 NET_43 VDD P18 l=0.180u w=5.000u
M19 NET_65 I VDD VDD P18 l=0.180u w=5.000u
M20 NET_65 I VDD VDD P18 l=0.180u w=5.000u
M21 VDD OEN NET_67 VDD P18 l=0.180u w=5.000u
M22 VDD OEN NET_67 VDD P18 l=0.180u w=5.000u
M23 VDD NET_65 NET_61 VDD P18 l=0.180u w=5.000u
M24 VDD NET_65 NET_61 VDD P18 l=0.180u w=5.000u
M25 VDD NET_67 NET_65 VDD P18 l=0.180u w=5.000u
M26 NET_65 NET_67 VDD VDD P18 l=0.180u w=5.000u
M27 NET_39 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M28 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M29 NET_41 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M30 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M31 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M32 NET_30 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M33 VSSD NET_23 NET_28 VSSD N33 l=0.400u w=28.000u
M34 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M35 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M36 NET_26 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M38 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M39 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M40 NET_37 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_23 NET_35 VSSD N33 l=0.400u w=28.000u
M42 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M43 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M44 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M46 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M47 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M50 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M51 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M52 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M53 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M56 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M58 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M60 NET_81 NET_43 VSS VSS N33 l=0.350u w=8.000u
M61 NET_81 NET_43 VSS VSS N33 l=0.350u w=8.000u
M62 VSS NET_77 NET_82 VSS N33 l=0.350u w=8.000u
M63 VSS NET_77 NET_82 VSS N33 l=0.350u w=8.000u
M64 VSS NET_70 NET_77 VSS N33 l=0.350u w=8.000u
M65 NET_45 NET_46 VSS VSS N33 l=0.350u w=4.600u
M66 VSS NET_65 NET_46 VSS N33 l=0.350u w=5.330u
M67 VSS NET_65 NET_46 VSS N33 l=0.350u w=5.330u
M68 NET_46 NET_65 VSS VSS N33 l=0.350u w=5.330u
M69 VSS NET_61 NET_47 VSS N33 l=0.350u w=5.330u
M70 NET_47 NET_61 VSS VSS N33 l=0.350u w=5.330u
M71 VSS NET_61 NET_47 VSS N33 l=0.350u w=5.330u
M72 NET_57 OEN VSS VSS N33 l=0.350u w=7.440u
M73 NET_57 OEN VSS VSS N33 l=0.350u w=7.440u
M74 VSS NET_67 NET_55 VSS N33 l=0.350u w=7.440u
M75 NET_55 NET_67 VSS VSS N33 l=0.350u w=7.440u
M76 NET_60 NET_3462 NET_58 VSS N33 l=0.350u w=8.000u
M77 NET_60 NET_57 VSS VSS N33 l=0.350u w=8.000u
M78 VSS NET_70 NET_77 VSS N33 l=0.350u w=8.000u
M79 NET_6306 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M80 NET_6306 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M81 NET_6308 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M82 NET_6308 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M83 NET_1332 NET_1332 NET_1332 NET_1332 P33 l=1.070u w=5.000u
M84 PAD NET_58 NET_6221 NET_1332 P33 l=0.300u w=30.000u
M85 VDD33 NET_3462 NET_6221 NET_1332 P33 l=0.300u w=30.000u
M86 VDD33 NET_3462 NET_6295 NET_1332 P33 l=0.300u w=30.000u
M87 NET_6295 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M88 PAD NET_58 NET_6222 NET_1332 P33 l=0.300u w=30.000u
M89 VDD33 NET_3462 NET_6222 NET_1332 P33 l=0.300u w=30.000u
M90 VDD33 NET_3462 NET_6301 NET_1332 P33 l=0.300u w=30.000u
M91 NET_6301 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M92 PAD NET_58 NET_6293 NET_1332 P33 l=0.300u w=30.000u
M93 NET_6293 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M94 VDD33 NET_3462 NET_6291 NET_1332 P33 l=0.300u w=30.000u
M95 NET_6291 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M96 NET_6283 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M97 PAD NET_58 NET_6299 NET_1332 P33 l=0.300u w=30.000u
M98 NET_6299 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M99 VDD33 NET_3462 NET_6297 NET_1332 P33 l=0.300u w=30.000u
M100 NET_6297 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M101 NET_6286 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M102 NET_82 NET_77 VDD33 VDD33 P33 l=0.300u w=5.000u
M103 VDD33 NET_3462 NET_6281 NET_1332 P33 l=0.300u w=30.000u
M104 NET_6281 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M105 NET_6268 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M106 NET_6268 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M107 VDD33 NET_3462 NET_6284 NET_1332 P33 l=0.300u w=30.000u
M108 NET_6284 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M109 NET_6273 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M110 NET_6273 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M111 VDD33 VSS NET_3462 VDD33 P33 l=0.300u w=5.000u
M112 VDD33 NET_81 NET_77 VDD33 P33 l=0.300u w=5.000u
M113 VDD33 NET_77 NET_81 VDD33 P33 l=0.300u w=5.000u
M114 VDD33 NET_45 NET_6266 NET_1332 P33 l=0.300u w=30.000u
M115 NET_6266 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M116 PAD NET_58 NET_6264 NET_1332 P33 l=0.300u w=30.000u
M117 NET_6264 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M118 NET_6247 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M119 VDD33 NET_45 NET_6271 NET_1332 P33 l=0.300u w=30.000u
M120 NET_6271 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M121 PAD NET_58 NET_6269 NET_1332 P33 l=0.300u w=30.000u
M122 NET_6269 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M123 NET_6251 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M124 VDD33 NET_57 NET_55 VDD33 P33 l=0.300u w=5.000u
M125 VDD33 NET_55 NET_57 VDD33 P33 l=0.300u w=5.000u
M126 PAD NET_58 NET_6245 NET_1332 P33 l=0.300u w=30.000u
M127 NET_6245 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M128 PAD NET_58 NET_6249 NET_1332 P33 l=0.300u w=30.000u
M129 NET_6249 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M130 NET_1332 PAD VDD33 NET_1332 P33 l=0.350u w=5.000u
M131 NET_1332 PAD VDD33 NET_1332 P33 l=0.350u w=5.000u
M132 VDD33 PAD NET_1332 NET_1332 P33 l=0.350u w=5.000u
M133 VDD33 NET_46 NET_45 VDD33 P33 l=0.300u w=5.000u
M134 VDD33 NET_46 NET_45 VDD33 P33 l=0.300u w=5.000u
M135 NET_45 NET_46 VDD33 VDD33 P33 l=0.300u w=5.000u
M136 VDD33 NET_46 NET_45 VDD33 P33 l=0.300u w=5.000u
M137 VDD33 NET_46 NET_47 VDD33 P33 l=0.300u w=5.000u
M138 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M139 PAD VDD33 NET_58 NET_1332 P33 l=0.350u w=10.000u
M140 PAD VDD33 NET_1332 NET_1332 P33 l=0.350u w=15.000u
M141 NET_6283 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M142 NET_6247 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M143 NET_6286 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M144 NET_6251 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
.ends POTL8

.subckt POTL24   PAD OEN I FP
M1 VSS NET_65 NET_61 VSS N18 l=0.180u w=4.000u
M2 VSS NET_65 NET_61 VSS N18 l=0.180u w=4.000u
M3 NET_66 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_66 NET_67 NET_65 VSS N18 l=0.180u w=4.000u
M5 VSS OEN NET_67 VSS N18 l=0.180u w=2.000u
M6 VSS OEN NET_67 VSS N18 l=0.180u w=2.000u
M7 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M8 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M9 NET_70 I VSS VSS N18 l=0.180u w=2.000u
M10 VSS I NET_70 VSS N18 l=0.180u w=2.000u
M11 VSS NET_70 NET_43 VSS N18 l=0.180u w=2.000u
M12 VSS NET_70 NET_43 VSS N18 l=0.180u w=2.000u
M13 NET_6235 OEN NET_70 VDD P18 l=0.180u w=5.000u
M14 NET_6235 I VDD VDD P18 l=0.180u w=5.000u
M15 VDD NET_70 NET_43 VDD P18 l=0.180u w=5.000u
M16 VDD NET_70 NET_43 VDD P18 l=0.180u w=5.000u
M17 NET_43 NET_70 VDD VDD P18 l=0.180u w=5.000u
M18 VDD NET_70 NET_43 VDD P18 l=0.180u w=5.000u
M19 VDD OEN NET_67 VDD P18 l=0.180u w=5.000u
M20 VDD OEN NET_67 VDD P18 l=0.180u w=5.000u
M21 NET_65 I VDD VDD P18 l=0.180u w=5.000u
M22 NET_65 I VDD VDD P18 l=0.180u w=5.000u
M23 VDD NET_65 NET_61 VDD P18 l=0.180u w=5.000u
M24 VDD NET_65 NET_61 VDD P18 l=0.180u w=5.000u
M25 VDD NET_67 NET_65 VDD P18 l=0.180u w=5.000u
M26 NET_65 NET_67 VDD VDD P18 l=0.180u w=5.000u
M27 NET_39 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M28 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M29 NET_41 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M30 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M31 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M32 NET_30 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M33 VSSD NET_82 NET_28 VSSD N33 l=0.400u w=28.000u
M34 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M35 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M36 NET_26 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_82 NET_24 VSSD N33 l=0.400u w=28.000u
M38 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M39 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M40 NET_37 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_82 NET_35 VSSD N33 l=0.400u w=28.000u
M42 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M43 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M44 NET_33 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M46 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M47 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_15 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_82 NET_13 VSSD N33 l=0.400u w=28.000u
M50 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M51 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M52 NET_11 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M53 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M56 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M58 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M60 NET_81 NET_43 VSS VSS N33 l=0.350u w=8.000u
M61 NET_81 NET_43 VSS VSS N33 l=0.350u w=8.000u
M62 VSS NET_77 NET_82 VSS N33 l=0.350u w=8.000u
M63 VSS NET_77 NET_82 VSS N33 l=0.350u w=8.000u
M64 NET_48 OEN VSS VSS N33 l=0.350u w=7.440u
M65 NET_48 OEN VSS VSS N33 l=0.350u w=7.440u
M66 VSS NET_67 NET_46 VSS N33 l=0.350u w=7.440u
M67 NET_46 NET_67 VSS VSS N33 l=0.350u w=7.440u
M68 NET_50 NET_51 VSS VSS N33 l=0.350u w=4.400u
M69 VSS NET_65 NET_51 VSS N33 l=0.350u w=5.330u
M70 VSS NET_65 NET_51 VSS N33 l=0.350u w=5.330u
M71 NET_51 NET_65 VSS VSS N33 l=0.350u w=5.330u
M72 VSS NET_61 NET_52 VSS N33 l=0.350u w=5.330u
M73 NET_52 NET_61 VSS VSS N33 l=0.350u w=5.330u
M74 VSS NET_61 NET_52 VSS N33 l=0.350u w=5.330u
M75 NET_60 NET_3462 NET_58 VSS N33 l=0.350u w=8.000u
M76 NET_60 NET_48 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_70 NET_77 VSS N33 l=0.350u w=8.000u
M78 VSS NET_70 NET_77 VSS N33 l=0.350u w=8.000u
M79 NET_6304 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M80 NET_6304 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M81 NET_6306 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M82 NET_6306 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M83 NET_1332 NET_1332 NET_1332 NET_1332 P33 l=1.070u w=5.000u
M84 PAD NET_58 NET_6219 NET_1332 P33 l=0.300u w=30.000u
M85 VDD33 NET_50 NET_6219 NET_1332 P33 l=0.300u w=30.000u
M86 VDD33 NET_50 NET_6293 NET_1332 P33 l=0.300u w=30.000u
M87 NET_6293 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M88 PAD NET_58 NET_6220 NET_1332 P33 l=0.300u w=30.000u
M89 VDD33 NET_50 NET_6220 NET_1332 P33 l=0.300u w=30.000u
M90 VDD33 NET_50 NET_6299 NET_1332 P33 l=0.300u w=30.000u
M91 NET_6299 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M92 PAD NET_58 NET_6291 NET_1332 P33 l=0.300u w=30.000u
M93 NET_6291 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M94 VDD33 NET_50 NET_6289 NET_1332 P33 l=0.300u w=30.000u
M95 NET_6289 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M96 NET_6281 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M97 PAD NET_58 NET_6297 NET_1332 P33 l=0.300u w=30.000u
M98 NET_6297 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M99 VDD33 NET_50 NET_6295 NET_1332 P33 l=0.300u w=30.000u
M100 NET_6295 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M101 NET_6284 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M102 VDD33 NET_77 NET_82 VDD33 P33 l=0.300u w=4.600u
M103 VDD33 NET_50 NET_6279 NET_1332 P33 l=0.300u w=30.000u
M104 NET_6279 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M105 NET_6266 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M106 NET_6266 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M107 VDD33 NET_50 NET_6282 NET_1332 P33 l=0.300u w=30.000u
M108 NET_6282 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M109 NET_6271 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M110 NET_6271 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M111 VDD33 VSS NET_3462 VDD33 P33 l=0.300u w=5.000u
M112 VDD33 NET_81 NET_77 VDD33 P33 l=0.300u w=5.000u
M113 VDD33 NET_77 NET_81 VDD33 P33 l=0.300u w=5.000u
M114 VDD33 NET_50 NET_6264 NET_1332 P33 l=0.300u w=30.000u
M115 NET_6264 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M116 PAD NET_58 NET_6262 NET_1332 P33 l=0.300u w=30.000u
M117 NET_6262 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M118 NET_6245 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M119 VDD33 NET_50 NET_6269 NET_1332 P33 l=0.300u w=30.000u
M120 NET_6269 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M121 PAD NET_58 NET_6267 NET_1332 P33 l=0.300u w=30.000u
M122 NET_6267 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M123 NET_6249 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M124 VDD33 NET_48 NET_46 VDD33 P33 l=0.300u w=5.000u
M125 VDD33 NET_46 NET_48 VDD33 P33 l=0.300u w=5.000u
M126 PAD NET_58 NET_6243 NET_1332 P33 l=0.300u w=30.000u
M127 NET_6243 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M128 PAD NET_58 NET_6247 NET_1332 P33 l=0.300u w=30.000u
M129 NET_6247 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M130 NET_1332 PAD VDD33 NET_1332 P33 l=0.350u w=5.000u
M131 NET_1332 PAD VDD33 NET_1332 P33 l=0.350u w=5.000u
M132 VDD33 PAD NET_1332 NET_1332 P33 l=0.350u w=5.000u
M133 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M134 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M135 NET_50 NET_51 VDD33 VDD33 P33 l=0.300u w=5.000u
M136 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M137 VDD33 NET_51 NET_52 VDD33 P33 l=0.300u w=5.000u
M138 VDD33 NET_52 NET_51 VDD33 P33 l=0.300u w=5.000u
M139 PAD VDD33 NET_58 NET_1332 P33 l=0.350u w=10.000u
M140 PAD VDD33 NET_1332 NET_1332 P33 l=0.350u w=15.000u
M141 NET_6281 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M142 NET_6245 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M143 NET_6284 NET_50 VDD33 NET_1332 P33 l=0.300u w=30.000u
M144 NET_6249 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
.ends POTL24

.subckt POTL16   PAD OEN I FP
M1 VSS NET_65 NET_61 VSS N18 l=0.180u w=4.000u
M2 VSS NET_65 NET_61 VSS N18 l=0.180u w=4.000u
M3 NET_66 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_66 NET_67 NET_65 VSS N18 l=0.180u w=4.000u
M5 VSS OEN NET_67 VSS N18 l=0.180u w=2.000u
M6 VSS OEN NET_67 VSS N18 l=0.180u w=2.000u
M7 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M8 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M9 NET_70 I VSS VSS N18 l=0.180u w=2.000u
M10 VSS I NET_70 VSS N18 l=0.180u w=2.000u
M11 VSS NET_70 NET_43 VSS N18 l=0.180u w=2.000u
M12 VSS NET_70 NET_43 VSS N18 l=0.180u w=2.000u
M13 VDD NET_70 NET_43 VDD P18 l=0.180u w=5.000u
M14 VDD NET_70 NET_43 VDD P18 l=0.180u w=5.000u
M15 NET_43 NET_70 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_70 NET_43 VDD P18 l=0.180u w=5.000u
M17 NET_6228 OEN NET_70 VDD P18 l=0.180u w=5.000u
M18 NET_6228 I VDD VDD P18 l=0.180u w=5.000u
M19 NET_65 I VDD VDD P18 l=0.180u w=5.000u
M20 NET_65 I VDD VDD P18 l=0.180u w=5.000u
M21 VDD OEN NET_67 VDD P18 l=0.180u w=5.000u
M22 VDD OEN NET_67 VDD P18 l=0.180u w=5.000u
M23 VDD NET_65 NET_61 VDD P18 l=0.180u w=5.000u
M24 VDD NET_65 NET_61 VDD P18 l=0.180u w=5.000u
M25 VDD NET_67 NET_65 VDD P18 l=0.180u w=5.000u
M26 NET_65 NET_67 VDD VDD P18 l=0.180u w=5.000u
M27 NET_39 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M28 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M29 NET_41 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M30 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M31 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M32 NET_30 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M33 VSSD NET_82 NET_28 VSSD N33 l=0.400u w=28.000u
M34 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M35 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M36 NET_26 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M38 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M39 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M40 NET_37 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_82 NET_35 VSSD N33 l=0.400u w=28.000u
M42 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M43 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M44 NET_33 NET_82 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M46 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M47 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M50 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M51 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M52 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M53 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M56 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M58 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M60 NET_81 NET_43 VSS VSS N33 l=0.350u w=8.000u
M61 NET_81 NET_43 VSS VSS N33 l=0.350u w=8.000u
M62 VSS NET_77 NET_82 VSS N33 l=0.350u w=8.000u
M63 VSS NET_77 NET_82 VSS N33 l=0.350u w=8.000u
M64 VSS NET_70 NET_77 VSS N33 l=0.350u w=8.000u
M65 NET_45 NET_46 VSS VSS N33 l=0.350u w=3.400u
M66 VSS NET_65 NET_46 VSS N33 l=0.350u w=5.330u
M67 VSS NET_65 NET_46 VSS N33 l=0.350u w=5.330u
M68 NET_46 NET_65 VSS VSS N33 l=0.350u w=5.330u
M69 VSS NET_61 NET_47 VSS N33 l=0.350u w=5.330u
M70 NET_47 NET_61 VSS VSS N33 l=0.350u w=5.330u
M71 VSS NET_61 NET_47 VSS N33 l=0.350u w=5.330u
M72 NET_57 OEN VSS VSS N33 l=0.350u w=7.440u
M73 NET_57 OEN VSS VSS N33 l=0.350u w=7.440u
M74 VSS NET_67 NET_55 VSS N33 l=0.350u w=7.440u
M75 NET_55 NET_67 VSS VSS N33 l=0.350u w=7.440u
M76 NET_60 NET_3462 NET_58 VSS N33 l=0.350u w=8.000u
M77 NET_60 NET_57 VSS VSS N33 l=0.350u w=8.000u
M78 VSS NET_70 NET_77 VSS N33 l=0.350u w=8.000u
M79 NET_6296 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M80 NET_6296 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M81 NET_6298 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M82 NET_6298 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M83 NET_1332 NET_1332 NET_1332 NET_1332 P33 l=1.070u w=5.000u
M84 PAD NET_58 NET_6209 NET_1332 P33 l=0.300u w=30.000u
M85 VDD33 NET_3462 NET_6209 NET_1332 P33 l=0.300u w=30.000u
M86 VDD33 NET_3462 NET_6285 NET_1332 P33 l=0.300u w=30.000u
M87 NET_6285 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M88 PAD NET_58 NET_6210 NET_1332 P33 l=0.300u w=30.000u
M89 VDD33 NET_3462 NET_6210 NET_1332 P33 l=0.300u w=30.000u
M90 VDD33 NET_3462 NET_6291 NET_1332 P33 l=0.300u w=30.000u
M91 NET_6291 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M92 PAD NET_58 NET_6283 NET_1332 P33 l=0.300u w=30.000u
M93 NET_6283 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M94 VDD33 NET_45 NET_6281 NET_1332 P33 l=0.300u w=30.000u
M95 NET_6281 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M96 NET_6273 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M97 PAD NET_58 NET_6289 NET_1332 P33 l=0.300u w=30.000u
M98 NET_6289 NET_3462 VDD33 NET_1332 P33 l=0.300u w=30.000u
M99 VDD33 NET_45 NET_6287 NET_1332 P33 l=0.300u w=30.000u
M100 NET_6287 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M101 NET_6276 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M102 NET_82 NET_77 VDD33 VDD33 P33 l=0.300u w=3.600u
M103 VDD33 NET_45 NET_6271 NET_1332 P33 l=0.300u w=30.000u
M104 NET_6271 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M105 NET_6258 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M106 NET_6258 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M107 VDD33 NET_45 NET_6274 NET_1332 P33 l=0.300u w=30.000u
M108 NET_6274 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M109 NET_6263 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M110 NET_6263 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M111 VDD33 VSS NET_3462 VDD33 P33 l=0.300u w=5.000u
M112 VDD33 NET_81 NET_77 VDD33 P33 l=0.300u w=5.000u
M113 VDD33 NET_77 NET_81 VDD33 P33 l=0.300u w=5.000u
M114 VDD33 NET_45 NET_6256 NET_1332 P33 l=0.300u w=30.000u
M115 NET_6256 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M116 PAD NET_58 NET_6254 NET_1332 P33 l=0.300u w=30.000u
M117 NET_6254 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M118 NET_6237 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M119 VDD33 NET_45 NET_6261 NET_1332 P33 l=0.300u w=30.000u
M120 NET_6261 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M121 PAD NET_58 NET_6259 NET_1332 P33 l=0.300u w=30.000u
M122 NET_6259 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M123 NET_6241 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M124 VDD33 NET_57 NET_55 VDD33 P33 l=0.300u w=5.000u
M125 VDD33 NET_55 NET_57 VDD33 P33 l=0.300u w=5.000u
M126 PAD NET_58 NET_6235 NET_1332 P33 l=0.300u w=30.000u
M127 NET_6235 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M128 PAD NET_58 NET_6239 NET_1332 P33 l=0.300u w=30.000u
M129 NET_6239 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M130 NET_1332 PAD VDD33 NET_1332 P33 l=0.350u w=5.000u
M131 NET_1332 PAD VDD33 NET_1332 P33 l=0.350u w=5.000u
M132 VDD33 PAD NET_1332 NET_1332 P33 l=0.350u w=5.000u
M133 VDD33 NET_46 NET_45 VDD33 P33 l=0.300u w=5.000u
M134 VDD33 NET_46 NET_45 VDD33 P33 l=0.300u w=5.000u
M135 NET_45 NET_46 VDD33 VDD33 P33 l=0.300u w=5.000u
M136 VDD33 NET_46 NET_45 VDD33 P33 l=0.300u w=5.000u
M137 VDD33 NET_46 NET_47 VDD33 P33 l=0.300u w=5.000u
M138 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M139 PAD VDD33 NET_1332 NET_1332 P33 l=0.350u w=15.000u
M140 NET_6273 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M141 NET_6237 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M142 NET_6276 NET_45 VDD33 NET_1332 P33 l=0.300u w=30.000u
M143 NET_6241 NET_58 PAD NET_1332 P33 l=0.300u w=30.000u
M144 PAD VDD33 NET_58 NET_1332 P33 l=0.350u w=10.000u
.ends POTL16

.subckt POTL12   PAD OEN I FP
M1 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M2 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M3 NET_67 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_67 NET_68 NET_66 VSS N18 l=0.180u w=4.000u
M5 VSS OEN NET_68 VSS N18 l=0.180u w=2.000u
M6 VSS OEN NET_68 VSS N18 l=0.180u w=2.000u
M7 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M8 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M9 NET_71 I VSS VSS N18 l=0.180u w=2.000u
M10 VSS I NET_71 VSS N18 l=0.180u w=2.000u
M11 VSS NET_71 NET_43 VSS N18 l=0.180u w=2.000u
M12 VSS NET_71 NET_43 VSS N18 l=0.180u w=2.000u
M13 NET_6260 OEN NET_71 VDD P18 l=0.180u w=5.000u
M14 NET_6260 I VDD VDD P18 l=0.180u w=5.000u
M15 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M16 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M17 NET_43 NET_71 VDD VDD P18 l=0.180u w=5.000u
M18 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M19 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M20 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M21 VDD OEN NET_68 VDD P18 l=0.180u w=5.000u
M22 VDD OEN NET_68 VDD P18 l=0.180u w=5.000u
M23 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M24 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M25 VDD NET_68 NET_66 VDD P18 l=0.180u w=5.000u
M26 NET_66 NET_68 VDD VDD P18 l=0.180u w=5.000u
M27 NET_39 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M28 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M29 NET_41 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M30 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M31 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M32 NET_30 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M33 VSSD NET_83 NET_28 VSSD N33 l=0.400u w=28.000u
M34 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M35 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M36 NET_26 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M38 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M39 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M40 NET_37 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_83 NET_35 VSSD N33 l=0.400u w=28.000u
M42 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M43 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M44 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M46 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M47 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M50 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M51 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M52 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M53 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M56 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M58 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M60 NET_82 NET_43 VSS VSS N33 l=0.350u w=8.000u
M61 NET_82 NET_43 VSS VSS N33 l=0.350u w=8.000u
M62 VSS NET_78 NET_83 VSS N33 l=0.350u w=8.000u
M63 VSS NET_78 NET_83 VSS N33 l=0.350u w=8.000u
M64 VSS NET_47 NET_44 VSS N33 l=0.350u w=5.000u
M65 VSS NET_47 NET_44 VSS N33 l=0.350u w=5.000u
M66 VSS NET_66 NET_47 VSS N33 l=0.350u w=5.330u
M67 VSS NET_66 NET_47 VSS N33 l=0.350u w=5.330u
M68 NET_47 NET_66 VSS VSS N33 l=0.350u w=5.330u
M69 VSS NET_62 NET_48 VSS N33 l=0.350u w=5.330u
M70 NET_48 NET_62 VSS VSS N33 l=0.350u w=5.330u
M71 VSS NET_62 NET_48 VSS N33 l=0.350u w=5.330u
M72 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M73 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M74 VSS NET_68 NET_56 VSS N33 l=0.350u w=7.440u
M75 NET_56 NET_68 VSS VSS N33 l=0.350u w=7.440u
M76 NET_61 NET_3463 NET_59 VSS N33 l=0.350u w=8.000u
M77 NET_61 NET_58 VSS VSS N33 l=0.350u w=8.000u
M78 VSS NET_71 NET_78 VSS N33 l=0.350u w=8.000u
M79 VSS NET_71 NET_78 VSS N33 l=0.350u w=8.000u
M80 NET_6330 NET_3463 VDD33 NET_1333 P33 l=0.300u w=30.000u
M81 NET_6330 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M82 NET_6332 NET_3463 VDD33 NET_1333 P33 l=0.300u w=30.000u
M83 NET_6332 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M84 NET_1333 NET_1333 NET_1333 NET_1333 P33 l=1.070u w=5.000u
M85 PAD NET_59 NET_6242 NET_1333 P33 l=0.300u w=30.000u
M86 VDD33 NET_3463 NET_6242 NET_1333 P33 l=0.300u w=30.000u
M87 VDD33 NET_3463 NET_6319 NET_1333 P33 l=0.300u w=30.000u
M88 NET_6319 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M89 PAD NET_59 NET_6243 NET_1333 P33 l=0.300u w=30.000u
M90 VDD33 NET_3463 NET_6243 NET_1333 P33 l=0.300u w=30.000u
M91 VDD33 NET_3463 NET_6325 NET_1333 P33 l=0.300u w=30.000u
M92 NET_6325 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M93 PAD NET_59 NET_6317 NET_1333 P33 l=0.300u w=30.000u
M94 NET_6317 NET_3463 VDD33 NET_1333 P33 l=0.300u w=30.000u
M95 VDD33 NET_3463 NET_6315 NET_1333 P33 l=0.300u w=30.000u
M96 NET_6315 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M97 NET_6306 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M98 PAD NET_59 NET_6323 NET_1333 P33 l=0.300u w=30.000u
M99 NET_6323 NET_3463 VDD33 NET_1333 P33 l=0.300u w=30.000u
M100 VDD33 NET_3463 NET_6321 NET_1333 P33 l=0.300u w=30.000u
M101 NET_6321 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M102 NET_6309 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M103 VDD33 NET_78 NET_83 VDD33 P33 l=0.300u w=4.800u
M104 VDD33 NET_78 NET_83 VDD33 P33 l=0.300u w=4.800u
M105 VDD33 NET_44 NET_6304 NET_1333 P33 l=0.300u w=30.000u
M106 NET_6304 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M107 NET_6291 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M108 NET_6291 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M109 VDD33 NET_44 NET_6307 NET_1333 P33 l=0.300u w=30.000u
M110 NET_6307 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M111 NET_6296 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M112 NET_6296 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M113 VDD33 VSS NET_3463 VDD33 P33 l=0.300u w=5.000u
M114 VDD33 NET_82 NET_78 VDD33 P33 l=0.300u w=5.000u
M115 VDD33 NET_78 NET_82 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_44 NET_6289 NET_1333 P33 l=0.300u w=30.000u
M117 NET_6289 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M118 PAD NET_59 NET_6287 NET_1333 P33 l=0.300u w=30.000u
M119 NET_6287 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M120 NET_6270 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M121 VDD33 NET_44 NET_6294 NET_1333 P33 l=0.300u w=30.000u
M122 NET_6294 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M123 PAD NET_59 NET_6292 NET_1333 P33 l=0.300u w=30.000u
M124 NET_6292 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M125 NET_6274 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M126 VDD33 NET_58 NET_56 VDD33 P33 l=0.300u w=5.000u
M127 VDD33 NET_56 NET_58 VDD33 P33 l=0.300u w=5.000u
M128 PAD NET_59 NET_6268 NET_1333 P33 l=0.300u w=30.000u
M129 NET_6268 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M130 PAD NET_59 NET_6272 NET_1333 P33 l=0.300u w=30.000u
M131 NET_6272 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M132 NET_1333 PAD VDD33 NET_1333 P33 l=0.350u w=5.000u
M133 NET_1333 PAD VDD33 NET_1333 P33 l=0.350u w=5.000u
M134 VDD33 PAD NET_1333 NET_1333 P33 l=0.350u w=5.000u
M135 VDD33 NET_47 NET_44 VDD33 P33 l=0.300u w=5.000u
M136 VDD33 NET_47 NET_44 VDD33 P33 l=0.300u w=5.000u
M137 NET_44 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 VDD33 NET_47 NET_44 VDD33 P33 l=0.300u w=5.000u
M139 VDD33 NET_47 NET_48 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M141 NET_6306 NET_3463 VDD33 NET_1333 P33 l=0.300u w=30.000u
M142 NET_6270 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M143 NET_6309 NET_3463 VDD33 NET_1333 P33 l=0.300u w=30.000u
M144 NET_6274 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M145 PAD VDD33 NET_1333 NET_1333 P33 l=0.350u w=15.000u
M146 PAD VDD33 NET_59 NET_1333 P33 l=0.350u w=10.000u
.ends POTL12

.subckt POT8   PAD OEN I FP
M1 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M2 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M3 NET_67 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_67 NET_68 NET_66 VSS N18 l=0.180u w=4.000u
M5 VSS OEN NET_68 VSS N18 l=0.180u w=2.000u
M6 VSS OEN NET_68 VSS N18 l=0.180u w=2.000u
M7 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M8 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M9 NET_71 I VSS VSS N18 l=0.180u w=2.000u
M10 VSS I NET_71 VSS N18 l=0.180u w=2.000u
M11 VSS NET_71 NET_43 VSS N18 l=0.180u w=2.000u
M12 VSS NET_71 NET_43 VSS N18 l=0.180u w=2.000u
M13 NET_6284 OEN NET_71 VDD P18 l=0.180u w=5.000u
M14 NET_6284 I VDD VDD P18 l=0.180u w=5.000u
M15 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M16 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M17 NET_43 NET_71 VDD VDD P18 l=0.180u w=5.000u
M18 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M19 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M20 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M21 VDD OEN NET_68 VDD P18 l=0.180u w=5.000u
M22 VDD OEN NET_68 VDD P18 l=0.180u w=5.000u
M23 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M24 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M25 VDD NET_68 NET_66 VDD P18 l=0.180u w=5.000u
M26 NET_66 NET_68 VDD VDD P18 l=0.180u w=5.000u
M27 NET_39 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M28 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M29 NET_41 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M30 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M31 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M32 NET_30 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M33 VSSD NET_23 NET_28 VSSD N33 l=0.400u w=28.000u
M34 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M35 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M36 NET_26 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M37 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M38 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M39 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M40 NET_37 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M41 VSSD NET_23 NET_35 VSSD N33 l=0.400u w=28.000u
M42 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M43 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M44 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M45 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M46 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M47 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M49 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M50 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M51 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M52 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M53 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M56 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M58 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M60 NET_82 NET_43 VSS VSS N33 l=0.350u w=8.000u
M61 NET_82 NET_43 VSS VSS N33 l=0.350u w=8.000u
M62 VSS NET_78 NET_83 VSS N33 l=0.350u w=8.000u
M63 VSS NET_78 NET_83 VSS N33 l=0.350u w=8.000u
M64 VSS NET_47 NET_44 VSS N33 l=0.350u w=10.000u
M65 VSS NET_47 NET_44 VSS N33 l=0.350u w=10.000u
M66 VSS NET_66 NET_47 VSS N33 l=0.350u w=5.330u
M67 VSS NET_66 NET_47 VSS N33 l=0.350u w=5.330u
M68 NET_47 NET_66 VSS VSS N33 l=0.350u w=5.330u
M69 VSS NET_62 NET_48 VSS N33 l=0.350u w=5.330u
M70 NET_48 NET_62 VSS VSS N33 l=0.350u w=5.330u
M71 VSS NET_62 NET_48 VSS N33 l=0.350u w=5.330u
M72 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M73 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M74 VSS NET_68 NET_56 VSS N33 l=0.350u w=7.440u
M75 NET_56 NET_68 VSS VSS N33 l=0.350u w=7.440u
M76 NET_61 NET_3467 NET_59 VSS N33 l=0.350u w=8.000u
M77 NET_61 NET_58 VSS VSS N33 l=0.350u w=8.000u
M78 VSS NET_71 NET_78 VSS N33 l=0.350u w=8.000u
M79 VSS NET_71 NET_78 VSS N33 l=0.350u w=8.000u
M80 NET_6355 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M81 NET_6355 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M82 NET_6357 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M83 NET_6357 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M84 NET_1333 NET_1333 NET_1333 NET_1333 P33 l=1.070u w=5.000u
M85 PAD NET_59 NET_6266 NET_1333 P33 l=0.300u w=30.000u
M86 VDD33 NET_3467 NET_6266 NET_1333 P33 l=0.300u w=30.000u
M87 VDD33 NET_3467 NET_6344 NET_1333 P33 l=0.300u w=30.000u
M88 NET_6344 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M89 PAD NET_59 NET_6267 NET_1333 P33 l=0.300u w=30.000u
M90 VDD33 NET_3467 NET_6267 NET_1333 P33 l=0.300u w=30.000u
M91 VDD33 NET_3467 NET_6350 NET_1333 P33 l=0.300u w=30.000u
M92 NET_6350 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M93 PAD NET_59 NET_6342 NET_1333 P33 l=0.300u w=30.000u
M94 NET_6342 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M95 VDD33 NET_3467 NET_6340 NET_1333 P33 l=0.300u w=30.000u
M96 NET_6340 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M97 NET_6329 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M98 PAD NET_59 NET_6348 NET_1333 P33 l=0.300u w=30.000u
M99 NET_6348 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M100 VDD33 NET_3467 NET_6346 NET_1333 P33 l=0.300u w=30.000u
M101 NET_6346 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M102 NET_6332 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M103 NET_83 NET_78 VDD33 VDD33 P33 l=0.300u w=5.000u
M104 NET_83 NET_78 VDD33 VDD33 P33 l=0.300u w=5.000u
M105 VDD33 NET_3467 NET_6327 NET_1333 P33 l=0.300u w=30.000u
M106 NET_6327 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M107 NET_6314 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M108 NET_6314 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M109 VDD33 NET_3467 NET_6330 NET_1333 P33 l=0.300u w=30.000u
M110 NET_6330 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M111 NET_6319 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M112 NET_6319 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M113 VDD33 VSS NET_3467 VDD33 P33 l=0.300u w=5.000u
M114 VDD33 NET_82 NET_78 VDD33 P33 l=0.300u w=5.000u
M115 VDD33 NET_78 NET_82 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_78 NET_83 VDD33 P33 l=0.300u w=5.000u
M117 NET_83 NET_78 VDD33 VDD33 P33 l=0.300u w=5.000u
M118 VDD33 NET_44 NET_6312 NET_1333 P33 l=0.300u w=30.000u
M119 NET_6312 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M120 PAD NET_59 NET_6310 NET_1333 P33 l=0.300u w=30.000u
M121 NET_6310 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M122 NET_6294 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M123 VDD33 NET_44 NET_6317 NET_1333 P33 l=0.300u w=30.000u
M124 NET_6317 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M125 PAD NET_59 NET_6315 NET_1333 P33 l=0.300u w=30.000u
M126 NET_6315 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M127 NET_6298 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M128 VDD33 NET_58 NET_56 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_56 NET_58 VDD33 P33 l=0.300u w=5.000u
M130 PAD NET_59 NET_6292 NET_1333 P33 l=0.300u w=30.000u
M131 NET_6292 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M132 PAD NET_59 NET_6296 NET_1333 P33 l=0.300u w=30.000u
M133 NET_6296 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M134 NET_1333 PAD VDD33 NET_1333 P33 l=0.350u w=5.000u
M135 NET_1333 PAD VDD33 NET_1333 P33 l=0.350u w=5.000u
M136 VDD33 PAD NET_1333 NET_1333 P33 l=0.350u w=5.000u
M137 NET_44 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_44 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 VDD33 NET_47 NET_44 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_47 NET_48 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M142 NET_6329 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M143 NET_6294 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M144 NET_6332 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M145 NET_6298 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M146 PAD VDD33 NET_1333 NET_1333 P33 l=0.350u w=15.000u
M147 PAD VDD33 NET_59 NET_1333 P33 l=0.350u w=10.000u
.ends POT8

.subckt POT4   PAD OEN I FP
M1 VSS NET_75 NET_71 VSS N18 l=0.180u w=4.000u
M2 VSS NET_75 NET_71 VSS N18 l=0.180u w=4.000u
M3 NET_76 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_76 NET_77 NET_75 VSS N18 l=0.180u w=4.000u
M5 VSS OEN NET_77 VSS N18 l=0.180u w=2.000u
M6 VSS OEN NET_77 VSS N18 l=0.180u w=2.000u
M7 VSS OEN NET_80 VSS N18 l=0.180u w=2.000u
M8 VSS OEN NET_80 VSS N18 l=0.180u w=2.000u
M9 NET_80 I VSS VSS N18 l=0.180u w=2.000u
M10 VSS I NET_80 VSS N18 l=0.180u w=2.000u
M11 VSS NET_80 NET_69 VSS N18 l=0.180u w=2.000u
M12 VSS NET_80 NET_69 VSS N18 l=0.180u w=2.000u
M13 VDD NET_80 NET_69 VDD P18 l=0.180u w=5.000u
M14 VDD NET_80 NET_69 VDD P18 l=0.180u w=5.000u
M15 NET_69 NET_80 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_80 NET_69 VDD P18 l=0.180u w=5.000u
M17 NET_6270 OEN NET_80 VDD P18 l=0.180u w=5.000u
M18 NET_6270 I VDD VDD P18 l=0.180u w=5.000u
M19 NET_75 I VDD VDD P18 l=0.180u w=5.000u
M20 NET_75 I VDD VDD P18 l=0.180u w=5.000u
M21 VDD OEN NET_77 VDD P18 l=0.180u w=5.000u
M22 VDD OEN NET_77 VDD P18 l=0.180u w=5.000u
M23 VDD NET_75 NET_71 VDD P18 l=0.180u w=5.000u
M24 VDD NET_75 NET_71 VDD P18 l=0.180u w=5.000u
M25 VDD NET_77 NET_75 VDD P18 l=0.180u w=5.000u
M26 NET_75 NET_77 VDD VDD P18 l=0.180u w=5.000u
M27 NET_39 NET_66 VSSD VSSD N33 l=0.400u w=28.000u
M28 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M29 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M30 NET_30 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M31 VSSD NET_23 NET_28 VSSD N33 l=0.400u w=28.000u
M32 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M33 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M34 NET_26 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M35 NET_41 NET_66 VSSD VSSD N33 l=0.400u w=28.000u
M36 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M37 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M38 NET_37 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M39 VSSD NET_23 NET_35 VSSD N33 l=0.400u w=28.000u
M40 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M41 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M42 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M43 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M44 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M48 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M50 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M52 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M56 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M58 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M60 NET_66 NET_42 VSS VSS N33 l=0.350u w=4.000u
M61 NET_66 NET_42 VSS VSS N33 l=0.350u w=4.000u
M62 VSS NET_42 NET_66 VSS N33 l=0.350u w=4.000u
M63 VSS NET_46 NET_43 VSS N33 l=0.350u w=8.000u
M64 VSS NET_46 NET_43 VSS N33 l=0.350u w=8.000u
M65 VSS NET_75 NET_46 VSS N33 l=0.350u w=5.330u
M66 VSS NET_75 NET_46 VSS N33 l=0.350u w=5.330u
M67 NET_46 NET_75 VSS VSS N33 l=0.350u w=5.330u
M68 VSS NET_71 NET_47 VSS N33 l=0.350u w=5.330u
M69 NET_47 NET_71 VSS VSS N33 l=0.350u w=5.330u
M70 VSS NET_71 NET_47 VSS N33 l=0.350u w=5.330u
M71 NET_57 OEN VSS VSS N33 l=0.350u w=7.440u
M72 NET_57 OEN VSS VSS N33 l=0.350u w=7.440u
M73 VSS NET_77 NET_55 VSS N33 l=0.350u w=7.440u
M74 NET_55 NET_77 VSS VSS N33 l=0.350u w=7.440u
M75 NET_60 NET_3477 NET_58 VSS N33 l=0.350u w=8.000u
M76 NET_60 NET_57 VSS VSS N33 l=0.350u w=8.000u
M77 NET_64 NET_69 VSS VSS N33 l=0.350u w=8.000u
M78 NET_64 NET_69 VSS VSS N33 l=0.350u w=8.000u
M79 VSS NET_80 NET_42 VSS N33 l=0.350u w=8.000u
M80 VSS NET_80 NET_42 VSS N33 l=0.350u w=8.000u
M81 NET_6338 NET_3477 VDD33 NET_1334 P33 l=0.300u w=30.000u
M82 NET_6338 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M83 NET_6340 NET_3477 VDD33 NET_1334 P33 l=0.300u w=30.000u
M84 NET_6340 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M85 NET_1334 NET_1334 NET_1334 NET_1334 P33 l=1.070u w=5.000u
M86 PAD NET_58 NET_6253 NET_1334 P33 l=0.300u w=30.000u
M87 VDD33 NET_3477 NET_6253 NET_1334 P33 l=0.300u w=30.000u
M88 VDD33 NET_3477 NET_6327 NET_1334 P33 l=0.300u w=30.000u
M89 NET_6327 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M90 PAD NET_58 NET_6254 NET_1334 P33 l=0.300u w=30.000u
M91 VDD33 NET_3477 NET_6254 NET_1334 P33 l=0.300u w=30.000u
M92 VDD33 NET_3477 NET_6333 NET_1334 P33 l=0.300u w=30.000u
M93 NET_6333 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M94 PAD NET_58 NET_6325 NET_1334 P33 l=0.300u w=30.000u
M95 NET_6325 NET_3477 VDD33 NET_1334 P33 l=0.300u w=30.000u
M96 VDD33 NET_3477 NET_6323 NET_1334 P33 l=0.300u w=30.000u
M97 NET_6323 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M98 NET_6313 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M99 PAD NET_58 NET_6331 NET_1334 P33 l=0.300u w=30.000u
M100 NET_6331 NET_3477 VDD33 NET_1334 P33 l=0.300u w=30.000u
M101 VDD33 NET_3477 NET_6329 NET_1334 P33 l=0.300u w=30.000u
M102 NET_6329 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M103 NET_6316 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M104 NET_66 NET_42 VDD33 VDD33 P33 l=0.300u w=5.000u
M105 NET_66 NET_42 VDD33 VDD33 P33 l=0.300u w=5.000u
M106 VDD33 NET_3477 NET_6311 NET_1334 P33 l=0.300u w=30.000u
M107 NET_6311 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M108 NET_6298 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M109 NET_6298 NET_3477 VDD33 NET_1334 P33 l=0.300u w=30.000u
M110 VDD33 NET_3477 NET_6314 NET_1334 P33 l=0.300u w=30.000u
M111 NET_6314 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M112 NET_6303 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M113 NET_6303 NET_3477 VDD33 NET_1334 P33 l=0.300u w=30.000u
M114 VDD33 VSS NET_3477 VDD33 P33 l=0.300u w=5.000u
M115 VDD33 NET_64 NET_42 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_42 NET_64 VDD33 P33 l=0.300u w=5.000u
M117 VDD33 NET_42 NET_66 VDD33 P33 l=0.300u w=5.000u
M118 VDD33 NET_3477 NET_6296 NET_1334 P33 l=0.300u w=30.000u
M119 NET_6296 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M120 PAD NET_58 NET_6294 NET_1334 P33 l=0.300u w=30.000u
M121 NET_6294 NET_3477 VDD33 NET_1334 P33 l=0.300u w=30.000u
M122 NET_6279 NET_43 VDD33 NET_1334 P33 l=0.300u w=30.000u
M123 VDD33 NET_3477 NET_6301 NET_1334 P33 l=0.300u w=30.000u
M124 NET_6301 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M125 PAD NET_58 NET_6299 NET_1334 P33 l=0.300u w=30.000u
M126 NET_6299 NET_3477 VDD33 NET_1334 P33 l=0.300u w=30.000u
M127 NET_6283 NET_43 VDD33 NET_1334 P33 l=0.300u w=30.000u
M128 VDD33 NET_57 NET_55 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_55 NET_57 VDD33 P33 l=0.300u w=5.000u
M130 PAD NET_58 NET_6277 NET_1334 P33 l=0.300u w=30.000u
M131 NET_6277 NET_43 VDD33 NET_1334 P33 l=0.300u w=30.000u
M132 PAD NET_58 NET_6281 NET_1334 P33 l=0.300u w=30.000u
M133 NET_6281 NET_43 VDD33 NET_1334 P33 l=0.300u w=30.000u
M134 NET_1334 PAD VDD33 NET_1334 P33 l=0.350u w=5.000u
M135 NET_1334 PAD VDD33 NET_1334 P33 l=0.350u w=5.000u
M136 VDD33 PAD NET_1334 NET_1334 P33 l=0.350u w=5.000u
M137 VDD33 NET_46 NET_43 VDD33 P33 l=0.300u w=5.000u
M138 VDD33 NET_46 NET_43 VDD33 P33 l=0.300u w=5.000u
M139 VDD33 NET_46 NET_47 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M141 PAD VDD33 NET_58 NET_1334 P33 l=0.350u w=10.000u
M142 PAD VDD33 NET_1334 NET_1334 P33 l=0.350u w=15.000u
M143 NET_6313 NET_3477 VDD33 NET_1334 P33 l=0.300u w=30.000u
M144 NET_6279 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
M145 NET_6316 NET_3477 VDD33 NET_1334 P33 l=0.300u w=30.000u
M146 NET_6283 NET_58 PAD NET_1334 P33 l=0.300u w=30.000u
.ends POT4

.subckt POT24   PAD OEN I FP
M1 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M2 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M3 NET_69 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_69 NET_70 NET_68 VSS N18 l=0.180u w=4.000u
M5 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M6 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M7 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M8 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M9 NET_73 I VSS VSS N18 l=0.180u w=2.000u
M10 VSS I NET_73 VSS N18 l=0.180u w=2.000u
M11 VSS NET_73 NET_42 VSS N18 l=0.180u w=2.000u
M12 VSS NET_73 NET_42 VSS N18 l=0.180u w=2.000u
M13 NET_6283 OEN NET_73 VDD P18 l=0.180u w=5.000u
M14 NET_6283 I VDD VDD P18 l=0.180u w=5.000u
M15 VDD NET_73 NET_42 VDD P18 l=0.180u w=5.000u
M16 VDD NET_73 NET_42 VDD P18 l=0.180u w=5.000u
M17 NET_42 NET_73 VDD VDD P18 l=0.180u w=5.000u
M18 VDD NET_73 NET_42 VDD P18 l=0.180u w=5.000u
M19 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M20 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M21 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M22 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M23 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M24 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M25 VDD NET_70 NET_68 VDD P18 l=0.180u w=5.000u
M26 NET_68 NET_70 VDD VDD P18 l=0.180u w=5.000u
M27 NET_39 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M28 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M29 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M30 NET_30 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M31 VSSD NET_83 NET_28 VSSD N33 l=0.400u w=28.000u
M32 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M33 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M34 NET_26 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M35 NET_41 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M36 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M37 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M38 NET_37 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M39 VSSD NET_83 NET_35 VSSD N33 l=0.400u w=28.000u
M40 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M41 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M42 NET_33 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M43 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M44 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M48 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M50 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_83 NET_31 VSSD N33 l=0.400u w=28.000u
M52 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_21 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_83 NET_19 VSSD N33 l=0.400u w=28.000u
M56 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M58 NET_17 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M60 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M61 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M62 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M63 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M64 NET_48 NET_68 VSS VSS N33 l=0.350u w=5.330u
M65 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M66 NET_49 NET_64 VSS VSS N33 l=0.350u w=5.330u
M67 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M68 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M69 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M70 VSS NET_70 NET_57 VSS N33 l=0.350u w=7.440u
M71 NET_57 NET_70 VSS VSS N33 l=0.350u w=7.440u
M72 NET_62 NET_3465 NET_60 VSS N33 l=0.350u w=8.000u
M73 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M74 NET_81 NET_42 VSS VSS N33 l=0.350u w=8.000u
M75 NET_81 NET_42 VSS VSS N33 l=0.350u w=8.000u
M76 VSS NET_73 NET_43 VSS N33 l=0.350u w=8.000u
M77 VSS NET_73 NET_43 VSS N33 l=0.350u w=8.000u
M78 NET_83 NET_43 VSS VSS N33 l=0.350u w=8.000u
M79 NET_83 NET_43 VSS VSS N33 l=0.350u w=8.000u
M80 VSS NET_43 NET_83 VSS N33 l=0.350u w=8.000u
M81 NET_6355 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M82 NET_6355 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M83 NET_6357 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M84 NET_6357 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M85 NET_1334 NET_1334 NET_1334 NET_1334 P33 l=1.070u w=5.000u
M86 PAD NET_60 NET_6265 NET_1334 P33 l=0.300u w=30.000u
M87 VDD33 NET_45 NET_6265 NET_1334 P33 l=0.300u w=30.000u
M88 VDD33 NET_45 NET_6344 NET_1334 P33 l=0.300u w=30.000u
M89 NET_6344 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M90 PAD NET_60 NET_6266 NET_1334 P33 l=0.300u w=30.000u
M91 VDD33 NET_45 NET_6266 NET_1334 P33 l=0.300u w=30.000u
M92 VDD33 NET_45 NET_6350 NET_1334 P33 l=0.300u w=30.000u
M93 NET_6350 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M94 PAD NET_60 NET_6342 NET_1334 P33 l=0.300u w=30.000u
M95 NET_6342 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M96 VDD33 NET_45 NET_6340 NET_1334 P33 l=0.300u w=30.000u
M97 NET_6340 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M98 NET_6330 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M99 PAD NET_60 NET_6348 NET_1334 P33 l=0.300u w=30.000u
M100 NET_6348 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M101 VDD33 NET_45 NET_6346 NET_1334 P33 l=0.300u w=30.000u
M102 NET_6346 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M103 NET_6333 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M104 NET_83 NET_43 VDD33 VDD33 P33 l=0.300u w=5.000u
M105 NET_83 NET_43 VDD33 VDD33 P33 l=0.300u w=5.000u
M106 VDD33 NET_45 NET_6328 NET_1334 P33 l=0.300u w=30.000u
M107 NET_6328 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M108 NET_6315 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M109 NET_6315 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M110 VDD33 NET_45 NET_6331 NET_1334 P33 l=0.300u w=30.000u
M111 NET_6331 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M112 NET_6320 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M113 NET_6320 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M114 VDD33 VSS NET_3465 VDD33 P33 l=0.300u w=5.000u
M115 VDD33 NET_81 NET_43 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_43 NET_81 VDD33 P33 l=0.300u w=5.000u
M117 VDD33 NET_43 NET_83 VDD33 P33 l=0.300u w=5.000u
M118 VDD33 NET_45 NET_6313 NET_1334 P33 l=0.300u w=30.000u
M119 NET_6313 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M120 PAD NET_60 NET_6311 NET_1334 P33 l=0.300u w=30.000u
M121 NET_6311 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M122 NET_6293 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M123 VDD33 NET_45 NET_6318 NET_1334 P33 l=0.300u w=30.000u
M124 NET_6318 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M125 PAD NET_60 NET_6316 NET_1334 P33 l=0.300u w=30.000u
M126 NET_6316 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M127 NET_6297 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M128 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M130 PAD NET_60 NET_6291 NET_1334 P33 l=0.300u w=30.000u
M131 NET_6291 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M132 PAD NET_60 NET_6295 NET_1334 P33 l=0.300u w=30.000u
M133 NET_6295 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M134 NET_1334 PAD VDD33 NET_1334 P33 l=0.350u w=5.000u
M135 NET_1334 PAD VDD33 NET_1334 P33 l=0.350u w=5.000u
M136 VDD33 PAD NET_1334 NET_1334 P33 l=0.350u w=5.000u
M137 NET_45 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_45 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M140 NET_45 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M143 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M144 NET_6330 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M145 NET_6293 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M146 NET_6333 NET_45 VDD33 NET_1334 P33 l=0.300u w=30.000u
M147 NET_6297 NET_60 PAD NET_1334 P33 l=0.300u w=30.000u
M148 PAD VDD33 NET_1334 NET_1334 P33 l=0.350u w=15.000u
M149 PAD VDD33 NET_60 NET_1334 P33 l=0.350u w=10.000u
.ends POT24

.subckt POT2   PAD OEN I FP
M1 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M2 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M3 NET_67 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_67 NET_68 NET_66 VSS N18 l=0.180u w=4.000u
M5 VSS OEN NET_68 VSS N18 l=0.180u w=2.000u
M6 VSS OEN NET_68 VSS N18 l=0.180u w=2.000u
M7 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M8 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M9 NET_71 I VSS VSS N18 l=0.180u w=2.000u
M10 VSS I NET_71 VSS N18 l=0.180u w=2.000u
M11 VSS NET_71 NET_43 VSS N18 l=0.180u w=2.000u
M12 VSS NET_71 NET_43 VSS N18 l=0.180u w=2.000u
M13 NET_6258 OEN NET_71 VDD P18 l=0.180u w=5.000u
M14 NET_6258 I VDD VDD P18 l=0.180u w=5.000u
M15 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M16 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M17 NET_43 NET_71 VDD VDD P18 l=0.180u w=5.000u
M18 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M19 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M20 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M21 VDD OEN NET_68 VDD P18 l=0.180u w=5.000u
M22 VDD OEN NET_68 VDD P18 l=0.180u w=5.000u
M23 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M24 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M25 VDD NET_68 NET_66 VDD P18 l=0.180u w=5.000u
M26 NET_66 NET_68 VDD VDD P18 l=0.180u w=5.000u
M27 NET_82 NET_43 VSS VSS N33 l=0.350u w=8.000u
M28 NET_82 NET_43 VSS VSS N33 l=0.350u w=8.000u
M29 VSS NET_78 NET_83 VSS N33 l=0.350u w=4.000u
M30 VSS NET_78 NET_83 VSS N33 l=0.350u w=4.000u
M31 NET_48 OEN VSS VSS N33 l=0.350u w=7.440u
M32 NET_48 OEN VSS VSS N33 l=0.350u w=7.440u
M33 VSS NET_68 NET_46 VSS N33 l=0.350u w=7.440u
M34 NET_46 NET_68 VSS VSS N33 l=0.350u w=7.440u
M35 VSS NET_71 NET_78 VSS N33 l=0.350u w=8.000u
M36 VSS NET_52 NET_49 VSS N33 l=0.350u w=4.000u
M37 VSS NET_52 NET_49 VSS N33 l=0.350u w=4.000u
M38 VSS NET_66 NET_52 VSS N33 l=0.350u w=5.330u
M39 VSS NET_66 NET_52 VSS N33 l=0.350u w=5.330u
M40 NET_52 NET_66 VSS VSS N33 l=0.350u w=5.330u
M41 VSS NET_62 NET_53 VSS N33 l=0.350u w=5.330u
M42 NET_53 NET_62 VSS VSS N33 l=0.350u w=5.330u
M43 VSS NET_62 NET_53 VSS N33 l=0.350u w=5.330u
M44 NET_61 NET_3472 NET_59 VSS N33 l=0.350u w=8.000u
M45 NET_61 NET_48 VSS VSS N33 l=0.350u w=8.000u
M46 VSS NET_71 NET_78 VSS N33 l=0.350u w=8.000u
M47 NET_39 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_41 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_30 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_23 NET_28 VSSD N33 l=0.400u w=28.000u
M54 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M56 NET_26 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M58 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_37 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M61 VSSD NET_23 NET_35 VSSD N33 l=0.400u w=28.000u
M62 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M63 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M64 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M65 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M66 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M70 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M72 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M74 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M76 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M77 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M78 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M80 NET_6326 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M81 NET_6326 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M82 NET_6328 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M83 NET_6328 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M84 NET_1333 NET_1333 NET_1333 NET_1333 P33 l=1.070u w=5.000u
M85 PAD NET_59 NET_6242 NET_1333 P33 l=0.300u w=30.000u
M86 VDD33 NET_3472 NET_6242 NET_1333 P33 l=0.300u w=30.000u
M87 VDD33 NET_3472 NET_6315 NET_1333 P33 l=0.300u w=30.000u
M88 NET_6315 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M89 PAD NET_59 NET_6243 NET_1333 P33 l=0.300u w=30.000u
M90 VDD33 NET_3472 NET_6243 NET_1333 P33 l=0.300u w=30.000u
M91 VDD33 NET_3472 NET_6321 NET_1333 P33 l=0.300u w=30.000u
M92 NET_6321 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M93 VDD33 NET_78 NET_83 VDD33 P33 l=0.300u w=5.000u
M94 PAD NET_59 NET_6313 NET_1333 P33 l=0.300u w=30.000u
M95 NET_6313 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M96 VDD33 NET_3472 NET_6311 NET_1333 P33 l=0.300u w=30.000u
M97 NET_6311 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M98 NET_6303 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M99 PAD NET_59 NET_6319 NET_1333 P33 l=0.300u w=30.000u
M100 NET_6319 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M101 VDD33 NET_3472 NET_6317 NET_1333 P33 l=0.300u w=30.000u
M102 NET_6317 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M103 NET_6306 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M104 VDD33 VSS NET_3472 VDD33 P33 l=0.300u w=5.000u
M105 VDD33 NET_82 NET_78 VDD33 P33 l=0.300u w=5.000u
M106 VDD33 NET_78 NET_82 VDD33 P33 l=0.300u w=5.000u
M107 VDD33 NET_3472 NET_6301 NET_1333 P33 l=0.300u w=30.000u
M108 NET_6301 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M109 NET_6288 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M110 NET_6288 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M111 VDD33 NET_3472 NET_6304 NET_1333 P33 l=0.300u w=30.000u
M112 NET_6304 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M113 NET_6293 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M114 NET_6293 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M115 VDD33 NET_48 NET_46 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_46 NET_48 VDD33 P33 l=0.300u w=5.000u
M117 VDD33 NET_3472 NET_6286 NET_1333 P33 l=0.300u w=30.000u
M118 NET_6286 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M119 PAD NET_59 NET_6284 NET_1333 P33 l=0.300u w=30.000u
M120 NET_6284 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M121 NET_6268 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M122 VDD33 NET_3472 NET_6291 NET_1333 P33 l=0.300u w=30.000u
M123 NET_6291 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M124 PAD NET_59 NET_6289 NET_1333 P33 l=0.300u w=30.000u
M125 NET_6289 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M126 NET_6272 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M127 VDD33 NET_52 NET_53 VDD33 P33 l=0.300u w=5.000u
M128 VDD33 NET_53 NET_52 VDD33 P33 l=0.300u w=5.000u
M129 NET_49 NET_52 VDD33 VDD33 P33 l=0.300u w=5.000u
M130 NET_49 NET_52 VDD33 VDD33 P33 l=0.300u w=5.000u
M131 VDD33 NET_52 NET_49 VDD33 P33 l=0.300u w=5.000u
M132 PAD NET_59 NET_6266 NET_1333 P33 l=0.300u w=30.000u
M133 NET_6266 NET_49 VDD33 NET_1333 P33 l=0.300u w=30.000u
M134 PAD NET_59 NET_6270 NET_1333 P33 l=0.300u w=30.000u
M135 NET_6270 NET_49 VDD33 NET_1333 P33 l=0.300u w=30.000u
M136 NET_1333 PAD VDD33 NET_1333 P33 l=0.350u w=5.000u
M137 NET_1333 PAD VDD33 NET_1333 P33 l=0.350u w=5.000u
M138 VDD33 PAD NET_1333 NET_1333 P33 l=0.350u w=5.000u
M139 PAD VDD33 NET_59 NET_1333 P33 l=0.350u w=10.000u
M140 PAD VDD33 NET_1333 NET_1333 P33 l=0.350u w=15.000u
M141 NET_6303 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M142 NET_6268 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M143 NET_6306 NET_3472 VDD33 NET_1333 P33 l=0.300u w=30.000u
M144 NET_6272 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
.ends POT2

.subckt POT16   PAD OEN I FP
M1 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M2 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M3 NET_67 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_67 NET_68 NET_66 VSS N18 l=0.180u w=4.000u
M5 VSS OEN NET_68 VSS N18 l=0.180u w=2.000u
M6 VSS OEN NET_68 VSS N18 l=0.180u w=2.000u
M7 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M8 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M9 NET_71 I VSS VSS N18 l=0.180u w=2.000u
M10 VSS I NET_71 VSS N18 l=0.180u w=2.000u
M11 VSS NET_71 NET_43 VSS N18 l=0.180u w=2.000u
M12 VSS NET_71 NET_43 VSS N18 l=0.180u w=2.000u
M13 NET_6284 OEN NET_71 VDD P18 l=0.180u w=5.000u
M14 NET_6284 I VDD VDD P18 l=0.180u w=5.000u
M15 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M16 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M17 NET_43 NET_71 VDD VDD P18 l=0.180u w=5.000u
M18 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M19 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M20 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M21 VDD OEN NET_68 VDD P18 l=0.180u w=5.000u
M22 VDD OEN NET_68 VDD P18 l=0.180u w=5.000u
M23 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M24 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M25 VDD NET_68 NET_66 VDD P18 l=0.180u w=5.000u
M26 NET_66 NET_68 VDD VDD P18 l=0.180u w=5.000u
M27 NET_82 NET_43 VSS VSS N33 l=0.350u w=8.000u
M28 NET_82 NET_43 VSS VSS N33 l=0.350u w=8.000u
M29 VSS NET_78 NET_83 VSS N33 l=0.350u w=8.000u
M30 VSS NET_78 NET_83 VSS N33 l=0.350u w=8.000u
M31 VSS NET_47 NET_44 VSS N33 l=0.350u w=10.000u
M32 VSS NET_47 NET_44 VSS N33 l=0.350u w=10.000u
M33 VSS NET_66 NET_47 VSS N33 l=0.350u w=5.330u
M34 VSS NET_66 NET_47 VSS N33 l=0.350u w=5.330u
M35 NET_47 NET_66 VSS VSS N33 l=0.350u w=5.330u
M36 VSS NET_62 NET_48 VSS N33 l=0.350u w=5.330u
M37 NET_48 NET_62 VSS VSS N33 l=0.350u w=5.330u
M38 VSS NET_62 NET_48 VSS N33 l=0.350u w=5.330u
M39 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M40 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M41 VSS NET_68 NET_56 VSS N33 l=0.350u w=7.440u
M42 NET_56 NET_68 VSS VSS N33 l=0.350u w=7.440u
M43 NET_61 NET_3467 NET_59 VSS N33 l=0.350u w=8.000u
M44 NET_61 NET_58 VSS VSS N33 l=0.350u w=8.000u
M45 VSS NET_71 NET_78 VSS N33 l=0.350u w=8.000u
M46 VSS NET_71 NET_78 VSS N33 l=0.350u w=8.000u
M47 NET_39 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_41 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_30 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_83 NET_28 VSSD N33 l=0.400u w=28.000u
M54 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M56 NET_26 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M58 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_37 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M61 VSSD NET_83 NET_35 VSSD N33 l=0.400u w=28.000u
M62 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M63 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M64 NET_33 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M65 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M66 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M70 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M72 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M74 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M76 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M77 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M78 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M80 NET_6355 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M81 NET_6355 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M82 NET_6357 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M83 NET_6357 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M84 NET_1333 NET_1333 NET_1333 NET_1333 P33 l=1.070u w=5.000u
M85 PAD NET_59 NET_6266 NET_1333 P33 l=0.300u w=30.000u
M86 VDD33 NET_3467 NET_6266 NET_1333 P33 l=0.300u w=30.000u
M87 VDD33 NET_3467 NET_6344 NET_1333 P33 l=0.300u w=30.000u
M88 NET_6344 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M89 PAD NET_59 NET_6267 NET_1333 P33 l=0.300u w=30.000u
M90 VDD33 NET_3467 NET_6267 NET_1333 P33 l=0.300u w=30.000u
M91 VDD33 NET_3467 NET_6350 NET_1333 P33 l=0.300u w=30.000u
M92 NET_6350 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M93 PAD NET_59 NET_6342 NET_1333 P33 l=0.300u w=30.000u
M94 NET_6342 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M95 VDD33 NET_44 NET_6340 NET_1333 P33 l=0.300u w=30.000u
M96 NET_6340 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M97 NET_6329 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M98 PAD NET_59 NET_6348 NET_1333 P33 l=0.300u w=30.000u
M99 NET_6348 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M100 VDD33 NET_44 NET_6346 NET_1333 P33 l=0.300u w=30.000u
M101 NET_6346 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M102 NET_6332 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M103 NET_83 NET_78 VDD33 VDD33 P33 l=0.300u w=5.000u
M104 NET_83 NET_78 VDD33 VDD33 P33 l=0.300u w=5.000u
M105 VDD33 NET_44 NET_6327 NET_1333 P33 l=0.300u w=30.000u
M106 NET_6327 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M107 NET_6314 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M108 NET_6314 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M109 VDD33 NET_44 NET_6330 NET_1333 P33 l=0.300u w=30.000u
M110 NET_6330 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M111 NET_6319 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M112 NET_6319 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M113 VDD33 VSS NET_3467 VDD33 P33 l=0.300u w=5.000u
M114 VDD33 NET_82 NET_78 VDD33 P33 l=0.300u w=5.000u
M115 VDD33 NET_78 NET_82 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_78 NET_83 VDD33 P33 l=0.300u w=5.000u
M117 NET_83 NET_78 VDD33 VDD33 P33 l=0.300u w=5.000u
M118 VDD33 NET_44 NET_6312 NET_1333 P33 l=0.300u w=30.000u
M119 NET_6312 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M120 PAD NET_59 NET_6310 NET_1333 P33 l=0.300u w=30.000u
M121 NET_6310 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M122 NET_6294 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M123 VDD33 NET_44 NET_6317 NET_1333 P33 l=0.300u w=30.000u
M124 NET_6317 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M125 PAD NET_59 NET_6315 NET_1333 P33 l=0.300u w=30.000u
M126 NET_6315 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M127 NET_6298 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M128 VDD33 NET_58 NET_56 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_56 NET_58 VDD33 P33 l=0.300u w=5.000u
M130 PAD NET_59 NET_6292 NET_1333 P33 l=0.300u w=30.000u
M131 NET_6292 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M132 PAD NET_59 NET_6296 NET_1333 P33 l=0.300u w=30.000u
M133 NET_6296 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M134 NET_1333 PAD VDD33 NET_1333 P33 l=0.350u w=5.000u
M135 NET_1333 PAD VDD33 NET_1333 P33 l=0.350u w=5.000u
M136 VDD33 PAD NET_1333 NET_1333 P33 l=0.350u w=5.000u
M137 NET_44 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_44 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 VDD33 NET_47 NET_44 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_47 NET_48 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M142 NET_6329 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M143 NET_6294 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M144 NET_6332 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M145 NET_6298 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M146 PAD VDD33 NET_1333 NET_1333 P33 l=0.350u w=15.000u
M147 PAD VDD33 NET_59 NET_1333 P33 l=0.350u w=10.000u
.ends POT16

.subckt POT12   PAD OEN I FP
M1 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M2 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M3 NET_67 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_67 NET_68 NET_66 VSS N18 l=0.180u w=4.000u
M5 VSS OEN NET_68 VSS N18 l=0.180u w=2.000u
M6 VSS OEN NET_68 VSS N18 l=0.180u w=2.000u
M7 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M8 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M9 NET_71 I VSS VSS N18 l=0.180u w=2.000u
M10 VSS I NET_71 VSS N18 l=0.180u w=2.000u
M11 VSS NET_71 NET_43 VSS N18 l=0.180u w=2.000u
M12 VSS NET_71 NET_43 VSS N18 l=0.180u w=2.000u
M13 NET_6284 OEN NET_71 VDD P18 l=0.180u w=5.000u
M14 NET_6284 I VDD VDD P18 l=0.180u w=5.000u
M15 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M16 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M17 NET_43 NET_71 VDD VDD P18 l=0.180u w=5.000u
M18 VDD NET_71 NET_43 VDD P18 l=0.180u w=5.000u
M19 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M20 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M21 VDD OEN NET_68 VDD P18 l=0.180u w=5.000u
M22 VDD OEN NET_68 VDD P18 l=0.180u w=5.000u
M23 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M24 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M25 VDD NET_68 NET_66 VDD P18 l=0.180u w=5.000u
M26 NET_66 NET_68 VDD VDD P18 l=0.180u w=5.000u
M27 NET_82 NET_43 VSS VSS N33 l=0.350u w=8.000u
M28 NET_82 NET_43 VSS VSS N33 l=0.350u w=8.000u
M29 VSS NET_78 NET_83 VSS N33 l=0.350u w=8.000u
M30 VSS NET_78 NET_83 VSS N33 l=0.350u w=8.000u
M31 VSS NET_47 NET_44 VSS N33 l=0.350u w=10.000u
M32 VSS NET_47 NET_44 VSS N33 l=0.350u w=10.000u
M33 VSS NET_66 NET_47 VSS N33 l=0.350u w=5.330u
M34 VSS NET_66 NET_47 VSS N33 l=0.350u w=5.330u
M35 NET_47 NET_66 VSS VSS N33 l=0.350u w=5.330u
M36 VSS NET_62 NET_48 VSS N33 l=0.350u w=5.330u
M37 NET_48 NET_62 VSS VSS N33 l=0.350u w=5.330u
M38 VSS NET_62 NET_48 VSS N33 l=0.350u w=5.330u
M39 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M40 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M41 VSS NET_68 NET_56 VSS N33 l=0.350u w=7.440u
M42 NET_56 NET_68 VSS VSS N33 l=0.350u w=7.440u
M43 NET_61 NET_3467 NET_59 VSS N33 l=0.350u w=8.000u
M44 NET_61 NET_58 VSS VSS N33 l=0.350u w=8.000u
M45 VSS NET_71 NET_78 VSS N33 l=0.350u w=8.000u
M46 VSS NET_71 NET_78 VSS N33 l=0.350u w=8.000u
M47 NET_39 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_41 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_30 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_83 NET_28 VSSD N33 l=0.400u w=28.000u
M54 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M56 NET_26 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M58 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_37 NET_83 VSSD VSSD N33 l=0.400u w=28.000u
M61 VSSD NET_83 NET_35 VSSD N33 l=0.400u w=28.000u
M62 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M63 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M64 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M65 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M66 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M70 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M72 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M74 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M76 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M77 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M78 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M80 NET_6355 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M81 NET_6355 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M82 NET_6357 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M83 NET_6357 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M84 NET_1333 NET_1333 NET_1333 NET_1333 P33 l=1.070u w=5.000u
M85 PAD NET_59 NET_6266 NET_1333 P33 l=0.300u w=30.000u
M86 VDD33 NET_3467 NET_6266 NET_1333 P33 l=0.300u w=30.000u
M87 VDD33 NET_3467 NET_6344 NET_1333 P33 l=0.300u w=30.000u
M88 NET_6344 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M89 PAD NET_59 NET_6267 NET_1333 P33 l=0.300u w=30.000u
M90 VDD33 NET_3467 NET_6267 NET_1333 P33 l=0.300u w=30.000u
M91 VDD33 NET_3467 NET_6350 NET_1333 P33 l=0.300u w=30.000u
M92 NET_6350 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M93 PAD NET_59 NET_6342 NET_1333 P33 l=0.300u w=30.000u
M94 NET_6342 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M95 VDD33 NET_3467 NET_6340 NET_1333 P33 l=0.300u w=30.000u
M96 NET_6340 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M97 NET_6329 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M98 PAD NET_59 NET_6348 NET_1333 P33 l=0.300u w=30.000u
M99 NET_6348 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M100 VDD33 NET_3467 NET_6346 NET_1333 P33 l=0.300u w=30.000u
M101 NET_6346 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M102 NET_6332 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M103 NET_83 NET_78 VDD33 VDD33 P33 l=0.300u w=5.000u
M104 NET_83 NET_78 VDD33 VDD33 P33 l=0.300u w=5.000u
M105 VDD33 NET_44 NET_6327 NET_1333 P33 l=0.300u w=30.000u
M106 NET_6327 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M107 NET_6314 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M108 NET_6314 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M109 VDD33 NET_44 NET_6330 NET_1333 P33 l=0.300u w=30.000u
M110 NET_6330 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M111 NET_6319 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M112 NET_6319 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M113 VDD33 VSS NET_3467 VDD33 P33 l=0.300u w=5.000u
M114 VDD33 NET_82 NET_78 VDD33 P33 l=0.300u w=5.000u
M115 VDD33 NET_78 NET_82 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_78 NET_83 VDD33 P33 l=0.300u w=5.000u
M117 NET_83 NET_78 VDD33 VDD33 P33 l=0.300u w=5.000u
M118 VDD33 NET_44 NET_6312 NET_1333 P33 l=0.300u w=30.000u
M119 NET_6312 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M120 PAD NET_59 NET_6310 NET_1333 P33 l=0.300u w=30.000u
M121 NET_6310 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M122 NET_6294 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M123 VDD33 NET_44 NET_6317 NET_1333 P33 l=0.300u w=30.000u
M124 NET_6317 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M125 PAD NET_59 NET_6315 NET_1333 P33 l=0.300u w=30.000u
M126 NET_6315 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M127 NET_6298 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M128 VDD33 NET_58 NET_56 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_56 NET_58 VDD33 P33 l=0.300u w=5.000u
M130 PAD NET_59 NET_6292 NET_1333 P33 l=0.300u w=30.000u
M131 NET_6292 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M132 PAD NET_59 NET_6296 NET_1333 P33 l=0.300u w=30.000u
M133 NET_6296 NET_44 VDD33 NET_1333 P33 l=0.300u w=30.000u
M134 NET_1333 PAD VDD33 NET_1333 P33 l=0.350u w=5.000u
M135 NET_1333 PAD VDD33 NET_1333 P33 l=0.350u w=5.000u
M136 VDD33 PAD NET_1333 NET_1333 P33 l=0.350u w=5.000u
M137 NET_44 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_44 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 VDD33 NET_47 NET_44 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_47 NET_48 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M142 NET_6329 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M143 NET_6294 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M144 NET_6332 NET_3467 VDD33 NET_1333 P33 l=0.300u w=30.000u
M145 NET_6298 NET_59 PAD NET_1333 P33 l=0.300u w=30.000u
M146 PAD VDD33 NET_1333 NET_1333 P33 l=0.350u w=15.000u
M147 PAD VDD33 NET_59 NET_1333 P33 l=0.350u w=10.000u
.ends POT12

.subckt POL8   PAD I FP
M1 VSS VSS NET_29 VSS N18 l=0.180u w=2.000u
M2 VSS VSS NET_29 VSS N18 l=0.180u w=2.000u
M3 NET_29 I VSS VSS N18 l=0.180u w=2.000u
M4 VSS I NET_29 VSS N18 l=0.180u w=2.000u
M5 VSS NET_29 NET_11 VSS N18 l=0.180u w=2.000u
M6 VSS NET_29 NET_11 VSS N18 l=0.180u w=2.000u
M7 VSS NET_47 NET_43 VSS N18 l=0.180u w=4.000u
M8 VSS NET_47 NET_43 VSS N18 l=0.180u w=4.000u
M9 NET_48 I VSS VSS N18 l=0.180u w=4.000u
M10 NET_48 VDD NET_47 VSS N18 l=0.180u w=4.000u
M11 NET_6287 VSS NET_29 VDD P18 l=0.180u w=5.000u
M12 NET_6287 I VDD VDD P18 l=0.180u w=5.000u
M13 VDD NET_29 NET_11 VDD P18 l=0.180u w=5.000u
M14 VDD NET_29 NET_11 VDD P18 l=0.180u w=5.000u
M15 NET_11 NET_29 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_29 NET_11 VDD P18 l=0.180u w=5.000u
M17 NET_47 I VDD VDD P18 l=0.180u w=5.000u
M18 NET_47 I VDD VDD P18 l=0.180u w=5.000u
M19 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M20 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M21 VDD VDD NET_47 VDD P18 l=0.180u w=5.000u
M22 NET_47 VDD VDD VDD P18 l=0.180u w=5.000u
M23 NET_74 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M24 NET_74 FP PAD VSSD N33 l=0.400u w=28.000u
M25 NET_56 FP PAD VSSD N33 l=0.400u w=28.000u
M26 NET_56 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M27 VSSD NET_25 NET_54 VSSD N33 l=0.400u w=28.000u
M28 NET_54 FP PAD VSSD N33 l=0.400u w=28.000u
M29 PAD FP NET_52 VSSD N33 l=0.400u w=28.000u
M30 NET_52 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M31 VSSD NET_25 NET_50 VSSD N33 l=0.400u w=28.000u
M32 NET_50 FP PAD VSSD N33 l=0.400u w=28.000u
M33 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M34 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M35 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M36 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M37 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M38 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M39 NET_76 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M40 NET_76 FP PAD VSSD N33 l=0.400u w=28.000u
M41 NET_63 FP PAD VSSD N33 l=0.400u w=28.000u
M42 NET_63 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M43 VSSD NET_25 NET_61 VSSD N33 l=0.400u w=28.000u
M44 NET_61 FP PAD VSSD N33 l=0.400u w=28.000u
M45 PAD FP NET_59 VSSD N33 l=0.400u w=28.000u
M46 NET_59 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_57 VSSD N33 l=0.400u w=28.000u
M48 NET_57 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M52 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M54 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M56 NET_35 NET_36 VSS VSS N33 l=0.350u w=4.600u
M57 VSS NET_47 NET_36 VSS N33 l=0.350u w=5.330u
M58 VSS NET_47 NET_36 VSS N33 l=0.350u w=5.330u
M59 NET_36 NET_47 VSS VSS N33 l=0.350u w=5.330u
M60 VSS NET_43 NET_37 VSS N33 l=0.350u w=5.330u
M61 NET_37 NET_43 VSS VSS N33 l=0.350u w=5.330u
M62 VSS NET_43 NET_37 VSS N33 l=0.350u w=5.330u
M63 NET_28 NET_3481 NET_26 VSS N33 l=0.350u w=8.000u
M64 NET_28 VDD33 VSS VSS N33 l=0.350u w=8.000u
M65 NET_69 NET_11 VSS VSS N33 l=0.350u w=8.000u
M66 NET_69 NET_11 VSS VSS N33 l=0.350u w=8.000u
M67 VSS NET_29 NET_64 VSS N33 l=0.350u w=8.000u
M68 NET_64 NET_29 VSS VSS N33 l=0.350u w=8.000u
M69 VSS NET_64 NET_70 VSS N33 l=0.350u w=8.000u
M70 VSS NET_64 NET_70 VSS N33 l=0.350u w=8.000u
M71 NET_6353 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M72 NET_6353 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M73 NET_6356 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M74 NET_6356 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M75 NET_1323 NET_1323 NET_1323 NET_1323 P33 l=1.070u w=5.000u
M76 PAD NET_26 NET_6273 NET_1323 P33 l=0.300u w=30.000u
M77 VDD33 NET_3481 NET_6273 NET_1323 P33 l=0.300u w=30.000u
M78 VDD33 NET_3481 NET_6343 NET_1323 P33 l=0.300u w=30.000u
M79 NET_6343 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M80 PAD NET_26 NET_6275 NET_1323 P33 l=0.300u w=30.000u
M81 VDD33 NET_3481 NET_6275 NET_1323 P33 l=0.300u w=30.000u
M82 VDD33 NET_3481 NET_6349 NET_1323 P33 l=0.300u w=30.000u
M83 NET_6349 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M84 PAD NET_26 NET_6341 NET_1323 P33 l=0.300u w=30.000u
M85 NET_6341 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M86 VDD33 NET_3481 NET_6339 NET_1323 P33 l=0.300u w=30.000u
M87 NET_6339 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M88 NET_6331 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M89 PAD NET_26 NET_6347 NET_1323 P33 l=0.300u w=30.000u
M90 NET_6347 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M91 VDD33 NET_3481 NET_6345 NET_1323 P33 l=0.300u w=30.000u
M92 NET_6345 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M93 NET_6334 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M94 NET_70 NET_64 VDD33 VDD33 P33 l=0.300u w=5.000u
M95 VDD33 NET_3481 NET_6329 NET_1323 P33 l=0.300u w=30.000u
M96 NET_6329 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M97 NET_6319 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M98 NET_6319 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M99 VDD33 NET_3481 NET_6332 NET_1323 P33 l=0.300u w=30.000u
M100 NET_6332 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M101 NET_6324 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M102 NET_6324 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M103 VDD33 VSS NET_3481 VDD33 P33 l=0.300u w=5.000u
M104 VDD33 NET_69 NET_64 VDD33 P33 l=0.300u w=5.000u
M105 VDD33 NET_64 NET_69 VDD33 P33 l=0.300u w=5.000u
M106 VDD33 NET_35 NET_6317 NET_1323 P33 l=0.300u w=30.000u
M107 NET_6317 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M108 PAD NET_26 NET_6315 NET_1323 P33 l=0.300u w=30.000u
M109 NET_6315 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M110 NET_6298 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M111 VDD33 NET_35 NET_6322 NET_1323 P33 l=0.300u w=30.000u
M112 NET_6322 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M113 PAD NET_26 NET_6320 NET_1323 P33 l=0.300u w=30.000u
M114 NET_6320 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M115 NET_6302 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M116 PAD NET_26 NET_6296 NET_1323 P33 l=0.300u w=30.000u
M117 NET_6296 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M118 PAD NET_26 NET_6300 NET_1323 P33 l=0.300u w=30.000u
M119 NET_6300 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M120 NET_1323 PAD VDD33 NET_1323 P33 l=0.350u w=5.000u
M121 NET_1323 PAD VDD33 NET_1323 P33 l=0.350u w=5.000u
M122 VDD33 PAD NET_1323 NET_1323 P33 l=0.350u w=5.000u
M123 VDD33 NET_36 NET_35 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_36 NET_35 VDD33 P33 l=0.300u w=5.000u
M125 NET_35 NET_36 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 VDD33 NET_36 NET_35 VDD33 P33 l=0.300u w=5.000u
M127 VDD33 NET_36 NET_37 VDD33 P33 l=0.300u w=5.000u
M128 VDD33 NET_37 NET_36 VDD33 P33 l=0.300u w=5.000u
M129 PAD VDD33 NET_26 NET_1323 P33 l=0.350u w=10.000u
M130 PAD VDD33 NET_1323 NET_1323 P33 l=0.350u w=15.000u
M131 NET_6331 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M132 NET_6298 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M133 NET_6334 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M134 NET_6302 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
.ends POL8

.subckt POL24   PAD I FP
M1 VSS VSS NET_29 VSS N18 l=0.180u w=2.000u
M2 VSS VSS NET_29 VSS N18 l=0.180u w=2.000u
M3 NET_29 I VSS VSS N18 l=0.180u w=2.000u
M4 VSS I NET_29 VSS N18 l=0.180u w=2.000u
M5 VSS NET_29 NET_11 VSS N18 l=0.180u w=2.000u
M6 VSS NET_29 NET_11 VSS N18 l=0.180u w=2.000u
M7 VSS NET_47 NET_43 VSS N18 l=0.180u w=4.000u
M8 VSS NET_47 NET_43 VSS N18 l=0.180u w=4.000u
M9 NET_48 I VSS VSS N18 l=0.180u w=4.000u
M10 NET_48 VDD NET_47 VSS N18 l=0.180u w=4.000u
M11 NET_6285 VSS NET_29 VDD P18 l=0.180u w=5.000u
M12 NET_6285 I VDD VDD P18 l=0.180u w=5.000u
M13 VDD NET_29 NET_11 VDD P18 l=0.180u w=5.000u
M14 VDD NET_29 NET_11 VDD P18 l=0.180u w=5.000u
M15 NET_11 NET_29 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_29 NET_11 VDD P18 l=0.180u w=5.000u
M17 NET_47 I VDD VDD P18 l=0.180u w=5.000u
M18 NET_47 I VDD VDD P18 l=0.180u w=5.000u
M19 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M20 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M21 VDD VDD NET_47 VDD P18 l=0.180u w=5.000u
M22 NET_47 VDD VDD VDD P18 l=0.180u w=5.000u
M23 NET_74 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M24 NET_74 FP PAD VSSD N33 l=0.400u w=28.000u
M25 NET_56 FP PAD VSSD N33 l=0.400u w=28.000u
M26 NET_56 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M27 VSSD NET_70 NET_54 VSSD N33 l=0.400u w=28.000u
M28 NET_54 FP PAD VSSD N33 l=0.400u w=28.000u
M29 PAD FP NET_52 VSSD N33 l=0.400u w=28.000u
M30 NET_52 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M31 VSSD NET_70 NET_50 VSSD N33 l=0.400u w=28.000u
M32 NET_50 FP PAD VSSD N33 l=0.400u w=28.000u
M33 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M34 NET_17 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M35 VSSD NET_70 NET_15 VSSD N33 l=0.400u w=28.000u
M36 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M37 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M38 NET_13 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M39 NET_76 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M40 NET_76 FP PAD VSSD N33 l=0.400u w=28.000u
M41 NET_63 FP PAD VSSD N33 l=0.400u w=28.000u
M42 NET_63 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M43 VSSD NET_70 NET_61 VSSD N33 l=0.400u w=28.000u
M44 NET_61 FP PAD VSSD N33 l=0.400u w=28.000u
M45 PAD FP NET_59 VSSD N33 l=0.400u w=28.000u
M46 NET_59 NET_70 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_57 VSSD N33 l=0.400u w=28.000u
M48 NET_57 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M52 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M54 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M56 NET_35 NET_36 VSS VSS N33 l=0.350u w=4.400u
M57 VSS NET_47 NET_36 VSS N33 l=0.350u w=5.330u
M58 VSS NET_47 NET_36 VSS N33 l=0.350u w=5.330u
M59 NET_36 NET_47 VSS VSS N33 l=0.350u w=5.330u
M60 VSS NET_43 NET_37 VSS N33 l=0.350u w=5.330u
M61 NET_37 NET_43 VSS VSS N33 l=0.350u w=5.330u
M62 VSS NET_43 NET_37 VSS N33 l=0.350u w=5.330u
M63 NET_69 NET_11 VSS VSS N33 l=0.350u w=8.000u
M64 NET_69 NET_11 VSS VSS N33 l=0.350u w=8.000u
M65 VSS NET_29 NET_64 VSS N33 l=0.350u w=8.000u
M66 NET_64 NET_29 VSS VSS N33 l=0.350u w=8.000u
M67 NET_28 NET_3481 NET_26 VSS N33 l=0.350u w=8.000u
M68 NET_28 VDD33 VSS VSS N33 l=0.350u w=8.000u
M69 VSS NET_64 NET_70 VSS N33 l=0.350u w=8.000u
M70 VSS NET_64 NET_70 VSS N33 l=0.350u w=8.000u
M71 NET_6351 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M72 NET_6351 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M73 NET_6354 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M74 NET_6354 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M75 NET_1323 NET_1323 NET_1323 NET_1323 P33 l=1.070u w=5.000u
M76 PAD NET_26 NET_6271 NET_1323 P33 l=0.300u w=30.000u
M77 VDD33 NET_35 NET_6271 NET_1323 P33 l=0.300u w=30.000u
M78 VDD33 NET_35 NET_6341 NET_1323 P33 l=0.300u w=30.000u
M79 NET_6341 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M80 PAD NET_26 NET_6273 NET_1323 P33 l=0.300u w=30.000u
M81 VDD33 NET_35 NET_6273 NET_1323 P33 l=0.300u w=30.000u
M82 VDD33 NET_35 NET_6347 NET_1323 P33 l=0.300u w=30.000u
M83 NET_6347 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M84 PAD NET_26 NET_6339 NET_1323 P33 l=0.300u w=30.000u
M85 NET_6339 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M86 VDD33 NET_35 NET_6337 NET_1323 P33 l=0.300u w=30.000u
M87 NET_6337 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M88 NET_6329 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M89 PAD NET_26 NET_6345 NET_1323 P33 l=0.300u w=30.000u
M90 NET_6345 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M91 VDD33 NET_35 NET_6343 NET_1323 P33 l=0.300u w=30.000u
M92 NET_6343 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M93 NET_6332 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M94 VDD33 NET_64 NET_70 VDD33 P33 l=0.300u w=4.600u
M95 VDD33 NET_35 NET_6327 NET_1323 P33 l=0.300u w=30.000u
M96 NET_6327 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M97 NET_6317 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M98 NET_6317 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M99 VDD33 NET_35 NET_6330 NET_1323 P33 l=0.300u w=30.000u
M100 NET_6330 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M101 NET_6322 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M102 NET_6322 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M103 VDD33 VSS NET_3481 VDD33 P33 l=0.300u w=5.000u
M104 VDD33 NET_69 NET_64 VDD33 P33 l=0.300u w=5.000u
M105 VDD33 NET_64 NET_69 VDD33 P33 l=0.300u w=5.000u
M106 VDD33 NET_35 NET_6315 NET_1323 P33 l=0.300u w=30.000u
M107 NET_6315 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M108 PAD NET_26 NET_6313 NET_1323 P33 l=0.300u w=30.000u
M109 NET_6313 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M110 NET_6296 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M111 VDD33 NET_35 NET_6320 NET_1323 P33 l=0.300u w=30.000u
M112 NET_6320 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M113 PAD NET_26 NET_6318 NET_1323 P33 l=0.300u w=30.000u
M114 NET_6318 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M115 NET_6300 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M116 PAD NET_26 NET_6294 NET_1323 P33 l=0.300u w=30.000u
M117 NET_6294 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M118 PAD NET_26 NET_6298 NET_1323 P33 l=0.300u w=30.000u
M119 NET_6298 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M120 NET_1323 PAD VDD33 NET_1323 P33 l=0.350u w=5.000u
M121 NET_1323 PAD VDD33 NET_1323 P33 l=0.350u w=5.000u
M122 VDD33 PAD NET_1323 NET_1323 P33 l=0.350u w=5.000u
M123 VDD33 NET_36 NET_35 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_36 NET_35 VDD33 P33 l=0.300u w=5.000u
M125 NET_35 NET_36 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 VDD33 NET_36 NET_35 VDD33 P33 l=0.300u w=5.000u
M127 VDD33 NET_36 NET_37 VDD33 P33 l=0.300u w=5.000u
M128 VDD33 NET_37 NET_36 VDD33 P33 l=0.300u w=5.000u
M129 PAD VDD33 NET_26 NET_1323 P33 l=0.350u w=10.000u
M130 PAD VDD33 NET_1323 NET_1323 P33 l=0.350u w=15.000u
M131 NET_6329 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M132 NET_6296 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M133 NET_6332 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M134 NET_6300 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
.ends POL24

.subckt POL16   PAD I FP
M1 VSS VSS NET_29 VSS N18 l=0.180u w=2.000u
M2 VSS VSS NET_29 VSS N18 l=0.180u w=2.000u
M3 NET_29 I VSS VSS N18 l=0.180u w=2.000u
M4 VSS I NET_29 VSS N18 l=0.180u w=2.000u
M5 VSS NET_29 NET_11 VSS N18 l=0.180u w=2.000u
M6 VSS NET_29 NET_11 VSS N18 l=0.180u w=2.000u
M7 VSS NET_47 NET_43 VSS N18 l=0.180u w=4.000u
M8 VSS NET_47 NET_43 VSS N18 l=0.180u w=4.000u
M9 NET_48 I VSS VSS N18 l=0.180u w=4.000u
M10 NET_48 VDD NET_47 VSS N18 l=0.180u w=4.000u
M11 NET_6277 VSS NET_29 VDD P18 l=0.180u w=5.000u
M12 NET_6277 I VDD VDD P18 l=0.180u w=5.000u
M13 VDD NET_29 NET_11 VDD P18 l=0.180u w=5.000u
M14 VDD NET_29 NET_11 VDD P18 l=0.180u w=5.000u
M15 NET_11 NET_29 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_29 NET_11 VDD P18 l=0.180u w=5.000u
M17 NET_47 I VDD VDD P18 l=0.180u w=5.000u
M18 NET_47 I VDD VDD P18 l=0.180u w=5.000u
M19 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M20 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M21 VDD VDD NET_47 VDD P18 l=0.180u w=5.000u
M22 NET_47 VDD VDD VDD P18 l=0.180u w=5.000u
M23 NET_74 NET_67 VSSD VSSD N33 l=0.400u w=28.000u
M24 NET_74 FP PAD VSSD N33 l=0.400u w=28.000u
M25 NET_56 FP PAD VSSD N33 l=0.400u w=28.000u
M26 NET_56 NET_67 VSSD VSSD N33 l=0.400u w=28.000u
M27 VSSD NET_67 NET_54 VSSD N33 l=0.400u w=28.000u
M28 NET_54 FP PAD VSSD N33 l=0.400u w=28.000u
M29 PAD FP NET_52 VSSD N33 l=0.400u w=28.000u
M30 NET_52 NET_67 VSSD VSSD N33 l=0.400u w=28.000u
M31 VSSD NET_25 NET_50 VSSD N33 l=0.400u w=28.000u
M32 NET_50 FP PAD VSSD N33 l=0.400u w=28.000u
M33 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M34 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M35 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M36 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M37 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M38 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M39 NET_76 NET_67 VSSD VSSD N33 l=0.400u w=28.000u
M40 NET_76 FP PAD VSSD N33 l=0.400u w=28.000u
M41 NET_63 FP PAD VSSD N33 l=0.400u w=28.000u
M42 NET_63 NET_67 VSSD VSSD N33 l=0.400u w=28.000u
M43 VSSD NET_67 NET_61 VSSD N33 l=0.400u w=28.000u
M44 NET_61 FP PAD VSSD N33 l=0.400u w=28.000u
M45 PAD FP NET_59 VSSD N33 l=0.400u w=28.000u
M46 NET_59 NET_67 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_57 VSSD N33 l=0.400u w=28.000u
M48 NET_57 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M52 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M54 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M56 NET_35 NET_36 VSS VSS N33 l=0.350u w=3.400u
M57 VSS NET_47 NET_36 VSS N33 l=0.350u w=5.330u
M58 VSS NET_47 NET_36 VSS N33 l=0.350u w=5.330u
M59 NET_36 NET_47 VSS VSS N33 l=0.350u w=5.330u
M60 VSS NET_43 NET_37 VSS N33 l=0.350u w=5.330u
M61 NET_37 NET_43 VSS VSS N33 l=0.350u w=5.330u
M62 VSS NET_43 NET_37 VSS N33 l=0.350u w=5.330u
M63 VSS NET_64 NET_67 VSS N33 l=0.350u w=8.000u
M64 VSS NET_64 NET_67 VSS N33 l=0.350u w=8.000u
M65 NET_28 NET_3481 NET_26 VSS N33 l=0.350u w=8.000u
M66 NET_28 VDD33 VSS VSS N33 l=0.350u w=8.000u
M67 NET_72 NET_11 VSS VSS N33 l=0.350u w=8.000u
M68 NET_72 NET_11 VSS VSS N33 l=0.350u w=8.000u
M69 VSS NET_29 NET_64 VSS N33 l=0.350u w=8.000u
M70 NET_64 NET_29 VSS VSS N33 l=0.350u w=8.000u
M71 NET_6343 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M72 NET_6343 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M73 NET_6346 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M74 NET_6346 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M75 NET_1323 NET_1323 NET_1323 NET_1323 P33 l=1.070u w=5.000u
M76 PAD NET_26 NET_6263 NET_1323 P33 l=0.300u w=30.000u
M77 VDD33 NET_3481 NET_6263 NET_1323 P33 l=0.300u w=30.000u
M78 VDD33 NET_3481 NET_6333 NET_1323 P33 l=0.300u w=30.000u
M79 NET_6333 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M80 PAD NET_26 NET_6265 NET_1323 P33 l=0.300u w=30.000u
M81 VDD33 NET_3481 NET_6265 NET_1323 P33 l=0.300u w=30.000u
M82 VDD33 NET_3481 NET_6339 NET_1323 P33 l=0.300u w=30.000u
M83 NET_6339 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M84 PAD NET_26 NET_6331 NET_1323 P33 l=0.300u w=30.000u
M85 NET_6331 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M86 VDD33 NET_35 NET_6329 NET_1323 P33 l=0.300u w=30.000u
M87 NET_6329 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M88 NET_6321 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M89 PAD NET_26 NET_6337 NET_1323 P33 l=0.300u w=30.000u
M90 NET_6337 NET_3481 VDD33 NET_1323 P33 l=0.300u w=30.000u
M91 VDD33 NET_35 NET_6335 NET_1323 P33 l=0.300u w=30.000u
M92 NET_6335 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M93 NET_6324 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M94 NET_67 NET_64 VDD33 VDD33 P33 l=0.300u w=3.600u
M95 VDD33 NET_35 NET_6319 NET_1323 P33 l=0.300u w=30.000u
M96 NET_6319 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M97 NET_6309 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M98 NET_6309 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M99 VDD33 NET_35 NET_6322 NET_1323 P33 l=0.300u w=30.000u
M100 NET_6322 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M101 NET_6314 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M102 NET_6314 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M103 VDD33 VSS NET_3481 VDD33 P33 l=0.300u w=5.000u
M104 VDD33 NET_72 NET_64 VDD33 P33 l=0.300u w=5.000u
M105 VDD33 NET_64 NET_72 VDD33 P33 l=0.300u w=5.000u
M106 VDD33 NET_35 NET_6307 NET_1323 P33 l=0.300u w=30.000u
M107 NET_6307 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M108 PAD NET_26 NET_6305 NET_1323 P33 l=0.300u w=30.000u
M109 NET_6305 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M110 NET_6288 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M111 VDD33 NET_35 NET_6312 NET_1323 P33 l=0.300u w=30.000u
M112 NET_6312 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M113 PAD NET_26 NET_6310 NET_1323 P33 l=0.300u w=30.000u
M114 NET_6310 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M115 NET_6292 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M116 PAD NET_26 NET_6286 NET_1323 P33 l=0.300u w=30.000u
M117 NET_6286 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M118 PAD NET_26 NET_6290 NET_1323 P33 l=0.300u w=30.000u
M119 NET_6290 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M120 NET_1323 PAD VDD33 NET_1323 P33 l=0.350u w=5.000u
M121 NET_1323 PAD VDD33 NET_1323 P33 l=0.350u w=5.000u
M122 VDD33 PAD NET_1323 NET_1323 P33 l=0.350u w=5.000u
M123 VDD33 NET_36 NET_35 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_36 NET_35 VDD33 P33 l=0.300u w=5.000u
M125 NET_35 NET_36 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 VDD33 NET_36 NET_35 VDD33 P33 l=0.300u w=5.000u
M127 VDD33 NET_36 NET_37 VDD33 P33 l=0.300u w=5.000u
M128 VDD33 NET_37 NET_36 VDD33 P33 l=0.300u w=5.000u
M129 PAD VDD33 NET_26 NET_1323 P33 l=0.350u w=10.000u
M130 PAD VDD33 NET_1323 NET_1323 P33 l=0.350u w=15.000u
M131 NET_6321 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M132 NET_6288 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
M133 NET_6324 NET_35 VDD33 NET_1323 P33 l=0.300u w=30.000u
M134 NET_6292 NET_26 PAD NET_1323 P33 l=0.300u w=30.000u
.ends POL16

.subckt POL12   PAD I FP
M1 VSS VSS NET_47 VSS N18 l=0.180u w=2.000u
M2 VSS VSS NET_47 VSS N18 l=0.180u w=2.000u
M3 NET_47 I VSS VSS N18 l=0.180u w=2.000u
M4 VSS I NET_47 VSS N18 l=0.180u w=2.000u
M5 VSS NET_47 NET_43 VSS N18 l=0.180u w=2.000u
M6 VSS NET_47 NET_43 VSS N18 l=0.180u w=2.000u
M7 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M8 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M9 NET_67 I VSS VSS N18 l=0.180u w=4.000u
M10 NET_67 VDD NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_6311 VSS NET_47 VDD P18 l=0.180u w=5.000u
M12 NET_6311 I VDD VDD P18 l=0.180u w=5.000u
M13 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M14 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M15 NET_43 NET_47 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M17 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M18 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M19 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M20 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M21 VDD VDD NET_66 VDD P18 l=0.180u w=5.000u
M22 NET_66 VDD VDD VDD P18 l=0.180u w=5.000u
M23 NET_39 NET_75 VSSD VSSD N33 l=0.400u w=28.000u
M24 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M25 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M26 NET_30 NET_75 VSSD VSSD N33 l=0.400u w=28.000u
M27 VSSD NET_75 NET_28 VSSD N33 l=0.400u w=28.000u
M28 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M29 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M30 NET_26 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M31 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M32 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M33 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M34 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M35 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M36 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M37 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M38 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M39 NET_41 NET_75 VSSD VSSD N33 l=0.400u w=28.000u
M40 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M41 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M42 NET_37 NET_75 VSSD VSSD N33 l=0.400u w=28.000u
M43 VSSD NET_75 NET_35 VSSD N33 l=0.400u w=28.000u
M44 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M45 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M46 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M48 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M52 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M54 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M56 VSS NET_55 NET_52 VSS N33 l=0.350u w=5.000u
M57 VSS NET_55 NET_52 VSS N33 l=0.350u w=5.000u
M58 VSS NET_66 NET_55 VSS N33 l=0.350u w=5.330u
M59 VSS NET_66 NET_55 VSS N33 l=0.350u w=5.330u
M60 NET_55 NET_66 VSS VSS N33 l=0.350u w=5.330u
M61 VSS NET_62 NET_56 VSS N33 l=0.350u w=5.330u
M62 NET_56 NET_62 VSS VSS N33 l=0.350u w=5.330u
M63 VSS NET_62 NET_56 VSS N33 l=0.350u w=5.330u
M64 NET_46 NET_3482 NET_44 VSS N33 l=0.350u w=8.000u
M65 NET_46 VDD33 VSS VSS N33 l=0.350u w=8.000u
M66 NET_74 NET_43 VSS VSS N33 l=0.350u w=8.000u
M67 NET_74 NET_43 VSS VSS N33 l=0.350u w=8.000u
M68 VSS NET_47 NET_69 VSS N33 l=0.350u w=8.000u
M69 VSS NET_47 NET_69 VSS N33 l=0.350u w=8.000u
M70 VSS NET_69 NET_75 VSS N33 l=0.350u w=8.000u
M71 VSS NET_69 NET_75 VSS N33 l=0.350u w=8.000u
M72 NET_6378 NET_3482 VDD33 NET_1324 P33 l=0.300u w=30.000u
M73 NET_6378 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M74 NET_6380 NET_3482 VDD33 NET_1324 P33 l=0.300u w=30.000u
M75 NET_6380 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M76 NET_1324 NET_1324 NET_1324 NET_1324 P33 l=1.070u w=5.000u
M77 PAD NET_44 NET_6296 NET_1324 P33 l=0.300u w=30.000u
M78 VDD33 NET_3482 NET_6296 NET_1324 P33 l=0.300u w=30.000u
M79 VDD33 NET_3482 NET_6367 NET_1324 P33 l=0.300u w=30.000u
M80 NET_6367 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M81 PAD NET_44 NET_6297 NET_1324 P33 l=0.300u w=30.000u
M82 VDD33 NET_3482 NET_6297 NET_1324 P33 l=0.300u w=30.000u
M83 VDD33 NET_3482 NET_6373 NET_1324 P33 l=0.300u w=30.000u
M84 NET_6373 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M85 PAD NET_44 NET_6365 NET_1324 P33 l=0.300u w=30.000u
M86 NET_6365 NET_3482 VDD33 NET_1324 P33 l=0.300u w=30.000u
M87 VDD33 NET_3482 NET_6363 NET_1324 P33 l=0.300u w=30.000u
M88 NET_6363 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M89 NET_6354 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M90 PAD NET_44 NET_6371 NET_1324 P33 l=0.300u w=30.000u
M91 NET_6371 NET_3482 VDD33 NET_1324 P33 l=0.300u w=30.000u
M92 VDD33 NET_3482 NET_6369 NET_1324 P33 l=0.300u w=30.000u
M93 NET_6369 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M94 NET_6357 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M95 VDD33 NET_69 NET_75 VDD33 P33 l=0.300u w=4.800u
M96 VDD33 NET_69 NET_75 VDD33 P33 l=0.300u w=4.800u
M97 VDD33 NET_52 NET_6352 NET_1324 P33 l=0.300u w=30.000u
M98 NET_6352 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M99 NET_6342 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M100 NET_6342 NET_52 VDD33 NET_1324 P33 l=0.300u w=30.000u
M101 VDD33 NET_52 NET_6355 NET_1324 P33 l=0.300u w=30.000u
M102 NET_6355 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M103 NET_6347 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M104 NET_6347 NET_52 VDD33 NET_1324 P33 l=0.300u w=30.000u
M105 VDD33 VSS NET_3482 VDD33 P33 l=0.300u w=5.000u
M106 VDD33 NET_74 NET_69 VDD33 P33 l=0.300u w=5.000u
M107 VDD33 NET_69 NET_74 VDD33 P33 l=0.300u w=5.000u
M108 VDD33 NET_52 NET_6340 NET_1324 P33 l=0.300u w=30.000u
M109 NET_6340 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M110 PAD NET_44 NET_6338 NET_1324 P33 l=0.300u w=30.000u
M111 NET_6338 NET_52 VDD33 NET_1324 P33 l=0.300u w=30.000u
M112 NET_6321 NET_52 VDD33 NET_1324 P33 l=0.300u w=30.000u
M113 VDD33 NET_52 NET_6345 NET_1324 P33 l=0.300u w=30.000u
M114 NET_6345 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M115 PAD NET_44 NET_6343 NET_1324 P33 l=0.300u w=30.000u
M116 NET_6343 NET_52 VDD33 NET_1324 P33 l=0.300u w=30.000u
M117 NET_6325 NET_52 VDD33 NET_1324 P33 l=0.300u w=30.000u
M118 PAD NET_44 NET_6319 NET_1324 P33 l=0.300u w=30.000u
M119 NET_6319 NET_52 VDD33 NET_1324 P33 l=0.300u w=30.000u
M120 PAD NET_44 NET_6323 NET_1324 P33 l=0.300u w=30.000u
M121 NET_6323 NET_52 VDD33 NET_1324 P33 l=0.300u w=30.000u
M122 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M123 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M124 VDD33 PAD NET_1324 NET_1324 P33 l=0.350u w=5.000u
M125 VDD33 NET_55 NET_52 VDD33 P33 l=0.300u w=5.000u
M126 VDD33 NET_55 NET_52 VDD33 P33 l=0.300u w=5.000u
M127 NET_52 NET_55 VDD33 VDD33 P33 l=0.300u w=5.000u
M128 VDD33 NET_55 NET_52 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_55 NET_56 VDD33 P33 l=0.300u w=5.000u
M130 VDD33 NET_56 NET_55 VDD33 P33 l=0.300u w=5.000u
M131 NET_6354 NET_3482 VDD33 NET_1324 P33 l=0.300u w=30.000u
M132 NET_6321 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M133 NET_6357 NET_3482 VDD33 NET_1324 P33 l=0.300u w=30.000u
M134 NET_6325 NET_44 PAD NET_1324 P33 l=0.300u w=30.000u
M135 PAD VDD33 NET_1324 NET_1324 P33 l=0.350u w=15.000u
M136 PAD VDD33 NET_44 NET_1324 P33 l=0.350u w=10.000u
.ends POL12

.subckt PO8   PAD I FP
M1 VSS VSS NET_64 VSS N18 l=0.180u w=2.000u
M2 VSS VSS NET_64 VSS N18 l=0.180u w=2.000u
M3 NET_64 I VSS VSS N18 l=0.180u w=2.000u
M4 VSS I NET_64 VSS N18 l=0.180u w=2.000u
M5 VSS NET_64 NET_60 VSS N18 l=0.180u w=2.000u
M6 VSS NET_64 NET_60 VSS N18 l=0.180u w=2.000u
M7 VSS NET_73 NET_69 VSS N18 l=0.180u w=4.000u
M8 VSS NET_73 NET_69 VSS N18 l=0.180u w=4.000u
M9 NET_74 I VSS VSS N18 l=0.180u w=4.000u
M10 NET_74 VDD NET_73 VSS N18 l=0.180u w=4.000u
M11 NET_6335 VSS NET_64 VDD P18 l=0.180u w=5.000u
M12 NET_6335 I VDD VDD P18 l=0.180u w=5.000u
M13 VDD NET_64 NET_60 VDD P18 l=0.180u w=5.000u
M14 VDD NET_64 NET_60 VDD P18 l=0.180u w=5.000u
M15 NET_60 NET_64 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_64 NET_60 VDD P18 l=0.180u w=5.000u
M17 NET_73 I VDD VDD P18 l=0.180u w=5.000u
M18 NET_73 I VDD VDD P18 l=0.180u w=5.000u
M19 VDD NET_73 NET_69 VDD P18 l=0.180u w=5.000u
M20 VDD NET_73 NET_69 VDD P18 l=0.180u w=5.000u
M21 VDD VDD NET_73 VDD P18 l=0.180u w=5.000u
M22 NET_73 VDD VDD VDD P18 l=0.180u w=5.000u
M23 NET_57 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M24 NET_57 FP PAD VSSD N33 l=0.400u w=28.000u
M25 NET_48 FP PAD VSSD N33 l=0.400u w=28.000u
M26 NET_48 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M27 VSSD NET_41 NET_46 VSSD N33 l=0.400u w=28.000u
M28 NET_46 FP PAD VSSD N33 l=0.400u w=28.000u
M29 PAD FP NET_44 VSSD N33 l=0.400u w=28.000u
M30 NET_44 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M31 VSSD NET_41 NET_42 VSSD N33 l=0.400u w=28.000u
M32 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M33 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M34 NET_33 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M35 VSSD NET_41 NET_31 VSSD N33 l=0.400u w=28.000u
M36 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M37 PAD FP NET_29 VSSD N33 l=0.400u w=28.000u
M38 NET_29 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M39 NET_59 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M40 NET_59 FP PAD VSSD N33 l=0.400u w=28.000u
M41 NET_55 FP PAD VSSD N33 l=0.400u w=28.000u
M42 NET_55 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M43 VSSD NET_41 NET_53 VSSD N33 l=0.400u w=28.000u
M44 NET_53 FP PAD VSSD N33 l=0.400u w=28.000u
M45 PAD FP NET_51 VSSD N33 l=0.400u w=28.000u
M46 NET_51 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_41 NET_49 VSSD N33 l=0.400u w=28.000u
M48 NET_49 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_39 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_41 NET_37 VSSD N33 l=0.400u w=28.000u
M52 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M54 NET_35 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_41 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M56 VSS NET_12 NET_9 VSS N33 l=0.350u w=10.000u
M57 VSS NET_12 NET_9 VSS N33 l=0.350u w=10.000u
M58 VSS NET_73 NET_12 VSS N33 l=0.350u w=5.330u
M59 VSS NET_73 NET_12 VSS N33 l=0.350u w=5.330u
M60 NET_12 NET_73 VSS VSS N33 l=0.350u w=5.330u
M61 VSS NET_69 NET_13 VSS N33 l=0.350u w=5.330u
M62 NET_13 NET_69 VSS VSS N33 l=0.350u w=5.330u
M63 VSS NET_69 NET_13 VSS N33 l=0.350u w=5.330u
M64 VSS NET_19 NET_20 VSS N33 l=0.350u w=8.000u
M65 VSS NET_19 NET_20 VSS N33 l=0.350u w=8.000u
M66 NET_63 NET_3486 NET_61 VSS N33 l=0.350u w=8.000u
M67 NET_63 VDD33 VSS VSS N33 l=0.350u w=8.000u
M68 NET_25 NET_60 VSS VSS N33 l=0.350u w=8.000u
M69 NET_25 NET_60 VSS VSS N33 l=0.350u w=8.000u
M70 VSS NET_64 NET_19 VSS N33 l=0.350u w=8.000u
M71 VSS NET_64 NET_19 VSS N33 l=0.350u w=8.000u
M72 NET_6403 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M73 NET_6403 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M74 NET_6405 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M75 NET_6405 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M76 NET_1324 NET_1324 NET_1324 NET_1324 P33 l=1.070u w=5.000u
M77 PAD NET_61 NET_6322 NET_1324 P33 l=0.300u w=30.000u
M78 VDD33 NET_3486 NET_6322 NET_1324 P33 l=0.300u w=30.000u
M79 VDD33 NET_3486 NET_6392 NET_1324 P33 l=0.300u w=30.000u
M80 NET_6392 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M81 PAD NET_61 NET_6323 NET_1324 P33 l=0.300u w=30.000u
M82 VDD33 NET_3486 NET_6323 NET_1324 P33 l=0.300u w=30.000u
M83 VDD33 NET_3486 NET_6398 NET_1324 P33 l=0.300u w=30.000u
M84 NET_6398 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M85 PAD NET_61 NET_6390 NET_1324 P33 l=0.300u w=30.000u
M86 NET_6390 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M87 VDD33 NET_3486 NET_6388 NET_1324 P33 l=0.300u w=30.000u
M88 NET_6388 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M89 NET_6377 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M90 PAD NET_61 NET_6396 NET_1324 P33 l=0.300u w=30.000u
M91 NET_6396 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M92 VDD33 NET_3486 NET_6394 NET_1324 P33 l=0.300u w=30.000u
M93 NET_6394 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M94 NET_6380 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M95 NET_20 NET_19 VDD33 VDD33 P33 l=0.300u w=5.000u
M96 NET_20 NET_19 VDD33 VDD33 P33 l=0.300u w=5.000u
M97 VDD33 NET_3486 NET_6375 NET_1324 P33 l=0.300u w=30.000u
M98 NET_6375 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M99 NET_6365 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M100 NET_6365 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M101 VDD33 NET_3486 NET_6378 NET_1324 P33 l=0.300u w=30.000u
M102 NET_6378 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M103 NET_6370 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M104 NET_6370 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M105 VDD33 NET_19 NET_20 VDD33 P33 l=0.300u w=5.000u
M106 NET_20 NET_19 VDD33 VDD33 P33 l=0.300u w=5.000u
M107 VDD33 VSS NET_3486 VDD33 P33 l=0.300u w=5.000u
M108 VDD33 NET_25 NET_19 VDD33 P33 l=0.300u w=5.000u
M109 VDD33 NET_19 NET_25 VDD33 P33 l=0.300u w=5.000u
M110 VDD33 NET_9 NET_6363 NET_1324 P33 l=0.300u w=30.000u
M111 NET_6363 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M112 PAD NET_61 NET_6361 NET_1324 P33 l=0.300u w=30.000u
M113 NET_6361 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M114 NET_6345 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M115 VDD33 NET_9 NET_6368 NET_1324 P33 l=0.300u w=30.000u
M116 NET_6368 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M117 PAD NET_61 NET_6366 NET_1324 P33 l=0.300u w=30.000u
M118 NET_6366 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M119 NET_6349 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M120 PAD NET_61 NET_6343 NET_1324 P33 l=0.300u w=30.000u
M121 NET_6343 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M122 PAD NET_61 NET_6347 NET_1324 P33 l=0.300u w=30.000u
M123 NET_6347 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M124 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M125 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M126 VDD33 PAD NET_1324 NET_1324 P33 l=0.350u w=5.000u
M127 NET_9 NET_12 VDD33 VDD33 P33 l=0.300u w=5.000u
M128 NET_9 NET_12 VDD33 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_12 NET_9 VDD33 P33 l=0.300u w=5.000u
M130 VDD33 NET_12 NET_13 VDD33 P33 l=0.300u w=5.000u
M131 VDD33 NET_13 NET_12 VDD33 P33 l=0.300u w=5.000u
M132 PAD VDD33 NET_61 NET_1324 P33 l=0.350u w=10.000u
M133 PAD VDD33 NET_1324 NET_1324 P33 l=0.350u w=15.000u
M134 NET_6377 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M135 NET_6345 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M136 NET_6380 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M137 NET_6349 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
.ends PO8

.subckt PO4   PAD I FP
M1 VSS NET_58 NET_54 VSS N18 l=0.180u w=4.000u
M2 VSS NET_58 NET_54 VSS N18 l=0.180u w=4.000u
M3 NET_59 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_59 VDD NET_58 VSS N18 l=0.180u w=4.000u
M5 VSS VSS NET_63 VSS N18 l=0.180u w=2.000u
M6 VSS VSS NET_63 VSS N18 l=0.180u w=2.000u
M7 NET_63 I VSS VSS N18 l=0.180u w=2.000u
M8 VSS I NET_63 VSS N18 l=0.180u w=2.000u
M9 VSS NET_63 NET_43 VSS N18 l=0.180u w=2.000u
M10 VSS NET_63 NET_43 VSS N18 l=0.180u w=2.000u
M11 NET_6319 VSS NET_63 VDD P18 l=0.180u w=5.000u
M12 NET_6319 I VDD VDD P18 l=0.180u w=5.000u
M13 VDD NET_63 NET_43 VDD P18 l=0.180u w=5.000u
M14 VDD NET_63 NET_43 VDD P18 l=0.180u w=5.000u
M15 NET_43 NET_63 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_63 NET_43 VDD P18 l=0.180u w=5.000u
M17 NET_58 I VDD VDD P18 l=0.180u w=5.000u
M18 NET_58 I VDD VDD P18 l=0.180u w=5.000u
M19 VDD NET_58 NET_54 VDD P18 l=0.180u w=5.000u
M20 VDD NET_58 NET_54 VDD P18 l=0.180u w=5.000u
M21 VDD VDD NET_58 VDD P18 l=0.180u w=5.000u
M22 NET_58 VDD VDD VDD P18 l=0.180u w=5.000u
M23 NET_62 NET_3496 NET_60 VSS N33 l=0.350u w=8.000u
M24 NET_62 VDD33 VSS VSS N33 l=0.350u w=8.000u
M25 NET_74 NET_43 VSS VSS N33 l=0.350u w=8.000u
M26 NET_74 NET_43 VSS VSS N33 l=0.350u w=8.000u
M27 VSS NET_63 NET_70 VSS N33 l=0.350u w=8.000u
M28 NET_70 NET_63 VSS VSS N33 l=0.350u w=8.000u
M29 NET_76 NET_70 VSS VSS N33 l=0.350u w=4.000u
M30 NET_76 NET_70 VSS VSS N33 l=0.350u w=4.000u
M31 VSS NET_70 NET_76 VSS N33 l=0.350u w=4.000u
M32 VSS NET_47 NET_44 VSS N33 l=0.350u w=8.000u
M33 VSS NET_47 NET_44 VSS N33 l=0.350u w=8.000u
M34 VSS NET_58 NET_47 VSS N33 l=0.350u w=5.330u
M35 VSS NET_58 NET_47 VSS N33 l=0.350u w=5.330u
M36 NET_47 NET_58 VSS VSS N33 l=0.350u w=5.330u
M37 VSS NET_54 NET_48 VSS N33 l=0.350u w=5.330u
M38 NET_48 NET_54 VSS VSS N33 l=0.350u w=5.330u
M39 VSS NET_54 NET_48 VSS N33 l=0.350u w=5.330u
M40 NET_39 NET_76 VSSD VSSD N33 l=0.400u w=28.000u
M41 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M42 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M43 NET_30 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M44 VSSD NET_23 NET_28 VSSD N33 l=0.400u w=28.000u
M45 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M46 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M47 NET_26 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M48 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M49 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M52 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M53 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M54 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M55 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_41 NET_76 VSSD VSSD N33 l=0.400u w=28.000u
M57 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_37 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M60 VSSD NET_23 NET_35 VSSD N33 l=0.400u w=28.000u
M61 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M62 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M63 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M65 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M68 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M69 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M70 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M71 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M72 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M73 NET_6385 NET_3496 VDD33 NET_1325 P33 l=0.300u w=30.000u
M74 NET_6385 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M75 NET_6388 NET_3496 VDD33 NET_1325 P33 l=0.300u w=30.000u
M76 NET_6388 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M77 NET_1325 NET_1325 NET_1325 NET_1325 P33 l=1.070u w=5.000u
M78 PAD NET_60 NET_6303 NET_1325 P33 l=0.300u w=30.000u
M79 VDD33 NET_3496 NET_6303 NET_1325 P33 l=0.300u w=30.000u
M80 VDD33 NET_3496 NET_6375 NET_1325 P33 l=0.300u w=30.000u
M81 NET_6375 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M82 PAD NET_60 NET_6305 NET_1325 P33 l=0.300u w=30.000u
M83 VDD33 NET_3496 NET_6305 NET_1325 P33 l=0.300u w=30.000u
M84 VDD33 NET_3496 NET_6381 NET_1325 P33 l=0.300u w=30.000u
M85 NET_6381 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M86 PAD NET_60 NET_6373 NET_1325 P33 l=0.300u w=30.000u
M87 NET_6373 NET_3496 VDD33 NET_1325 P33 l=0.300u w=30.000u
M88 VDD33 NET_3496 NET_6371 NET_1325 P33 l=0.300u w=30.000u
M89 NET_6371 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M90 NET_6361 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M91 PAD NET_60 NET_6379 NET_1325 P33 l=0.300u w=30.000u
M92 NET_6379 NET_3496 VDD33 NET_1325 P33 l=0.300u w=30.000u
M93 VDD33 NET_3496 NET_6377 NET_1325 P33 l=0.300u w=30.000u
M94 NET_6377 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M95 NET_6364 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M96 NET_76 NET_70 VDD33 VDD33 P33 l=0.300u w=5.000u
M97 NET_76 NET_70 VDD33 VDD33 P33 l=0.300u w=5.000u
M98 VDD33 NET_3496 NET_6359 NET_1325 P33 l=0.300u w=30.000u
M99 NET_6359 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M100 NET_6349 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M101 NET_6349 NET_3496 VDD33 NET_1325 P33 l=0.300u w=30.000u
M102 VDD33 NET_3496 NET_6362 NET_1325 P33 l=0.300u w=30.000u
M103 NET_6362 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M104 NET_6354 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M105 NET_6354 NET_3496 VDD33 NET_1325 P33 l=0.300u w=30.000u
M106 VDD33 VSS NET_3496 VDD33 P33 l=0.300u w=5.000u
M107 VDD33 NET_74 NET_70 VDD33 P33 l=0.300u w=5.000u
M108 VDD33 NET_70 NET_74 VDD33 P33 l=0.300u w=5.000u
M109 VDD33 NET_70 NET_76 VDD33 P33 l=0.300u w=5.000u
M110 VDD33 NET_3496 NET_6347 NET_1325 P33 l=0.300u w=30.000u
M111 NET_6347 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M112 PAD NET_60 NET_6345 NET_1325 P33 l=0.300u w=30.000u
M113 NET_6345 NET_3496 VDD33 NET_1325 P33 l=0.300u w=30.000u
M114 NET_6330 NET_44 VDD33 NET_1325 P33 l=0.300u w=30.000u
M115 VDD33 NET_3496 NET_6352 NET_1325 P33 l=0.300u w=30.000u
M116 NET_6352 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M117 PAD NET_60 NET_6350 NET_1325 P33 l=0.300u w=30.000u
M118 NET_6350 NET_3496 VDD33 NET_1325 P33 l=0.300u w=30.000u
M119 NET_6334 NET_44 VDD33 NET_1325 P33 l=0.300u w=30.000u
M120 PAD NET_60 NET_6328 NET_1325 P33 l=0.300u w=30.000u
M121 NET_6328 NET_44 VDD33 NET_1325 P33 l=0.300u w=30.000u
M122 PAD NET_60 NET_6332 NET_1325 P33 l=0.300u w=30.000u
M123 NET_6332 NET_44 VDD33 NET_1325 P33 l=0.300u w=30.000u
M124 NET_1325 PAD VDD33 NET_1325 P33 l=0.350u w=5.000u
M125 NET_1325 PAD VDD33 NET_1325 P33 l=0.350u w=5.000u
M126 VDD33 PAD NET_1325 NET_1325 P33 l=0.350u w=5.000u
M127 VDD33 NET_47 NET_44 VDD33 P33 l=0.300u w=5.000u
M128 VDD33 NET_47 NET_44 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_47 NET_48 VDD33 P33 l=0.300u w=5.000u
M130 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M131 PAD VDD33 NET_60 NET_1325 P33 l=0.350u w=10.000u
M132 NET_6361 NET_3496 VDD33 NET_1325 P33 l=0.300u w=30.000u
M133 NET_6330 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M134 NET_6364 NET_3496 VDD33 NET_1325 P33 l=0.300u w=30.000u
M135 NET_6334 NET_60 PAD NET_1325 P33 l=0.300u w=30.000u
M136 PAD VDD33 NET_1325 NET_1325 P33 l=0.350u w=15.000u
.ends PO4

.subckt PO24   PAD I FP
M1 VSS VSS NET_47 VSS N18 l=0.180u w=2.000u
M2 VSS VSS NET_47 VSS N18 l=0.180u w=2.000u
M3 NET_47 I VSS VSS N18 l=0.180u w=2.000u
M4 VSS I NET_47 VSS N18 l=0.180u w=2.000u
M5 VSS NET_47 NET_43 VSS N18 l=0.180u w=2.000u
M6 VSS NET_47 NET_43 VSS N18 l=0.180u w=2.000u
M7 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M8 VSS NET_66 NET_62 VSS N18 l=0.180u w=4.000u
M9 NET_67 I VSS VSS N18 l=0.180u w=4.000u
M10 NET_67 VDD NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_6334 VSS NET_47 VDD P18 l=0.180u w=5.000u
M12 NET_6334 I VDD VDD P18 l=0.180u w=5.000u
M13 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M14 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M15 NET_43 NET_47 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_47 NET_43 VDD P18 l=0.180u w=5.000u
M17 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M18 NET_66 I VDD VDD P18 l=0.180u w=5.000u
M19 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M20 VDD NET_66 NET_62 VDD P18 l=0.180u w=5.000u
M21 VDD VDD NET_66 VDD P18 l=0.180u w=5.000u
M22 NET_66 VDD VDD VDD P18 l=0.180u w=5.000u
M23 NET_39 NET_73 VSSD VSSD N33 l=0.400u w=28.000u
M24 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M25 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M26 NET_30 NET_73 VSSD VSSD N33 l=0.400u w=28.000u
M27 VSSD NET_73 NET_28 VSSD N33 l=0.400u w=28.000u
M28 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M29 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M30 NET_26 NET_73 VSSD VSSD N33 l=0.400u w=28.000u
M31 VSSD NET_73 NET_24 VSSD N33 l=0.400u w=28.000u
M32 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M33 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M34 NET_15 NET_73 VSSD VSSD N33 l=0.400u w=28.000u
M35 VSSD NET_73 NET_13 VSSD N33 l=0.400u w=28.000u
M36 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M37 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M38 NET_11 NET_73 VSSD VSSD N33 l=0.400u w=28.000u
M39 NET_41 NET_73 VSSD VSSD N33 l=0.400u w=28.000u
M40 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M41 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M42 NET_37 NET_73 VSSD VSSD N33 l=0.400u w=28.000u
M43 VSSD NET_73 NET_35 VSSD N33 l=0.400u w=28.000u
M44 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M45 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M46 NET_33 NET_73 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M48 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M52 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M54 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M56 VSS NET_55 NET_52 VSS N33 l=0.350u w=8.000u
M57 VSS NET_55 NET_52 VSS N33 l=0.350u w=8.000u
M58 VSS NET_66 NET_55 VSS N33 l=0.350u w=5.330u
M59 VSS NET_66 NET_55 VSS N33 l=0.350u w=5.330u
M60 NET_55 NET_66 VSS VSS N33 l=0.350u w=5.330u
M61 VSS NET_62 NET_56 VSS N33 l=0.350u w=5.330u
M62 NET_56 NET_62 VSS VSS N33 l=0.350u w=5.330u
M63 VSS NET_62 NET_56 VSS N33 l=0.350u w=5.330u
M64 NET_73 NET_70 VSS VSS N33 l=0.350u w=8.000u
M65 NET_73 NET_70 VSS VSS N33 l=0.350u w=8.000u
M66 VSS NET_70 NET_73 VSS N33 l=0.350u w=8.000u
M67 NET_46 NET_3484 NET_44 VSS N33 l=0.350u w=8.000u
M68 NET_46 VDD33 VSS VSS N33 l=0.350u w=8.000u
M69 NET_78 NET_43 VSS VSS N33 l=0.350u w=8.000u
M70 NET_78 NET_43 VSS VSS N33 l=0.350u w=8.000u
M71 VSS NET_47 NET_70 VSS N33 l=0.350u w=8.000u
M72 NET_70 NET_47 VSS VSS N33 l=0.350u w=8.000u
M73 NET_6403 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M74 NET_6403 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M75 NET_6405 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M76 NET_6405 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M77 NET_1325 NET_1325 NET_1325 NET_1325 P33 l=1.070u w=5.000u
M78 PAD NET_44 NET_6321 NET_1325 P33 l=0.300u w=30.000u
M79 VDD33 NET_52 NET_6321 NET_1325 P33 l=0.300u w=30.000u
M80 VDD33 NET_52 NET_6392 NET_1325 P33 l=0.300u w=30.000u
M81 NET_6392 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M82 PAD NET_44 NET_6322 NET_1325 P33 l=0.300u w=30.000u
M83 VDD33 NET_52 NET_6322 NET_1325 P33 l=0.300u w=30.000u
M84 VDD33 NET_52 NET_6398 NET_1325 P33 l=0.300u w=30.000u
M85 NET_6398 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M86 PAD NET_44 NET_6390 NET_1325 P33 l=0.300u w=30.000u
M87 NET_6390 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M88 VDD33 NET_52 NET_6388 NET_1325 P33 l=0.300u w=30.000u
M89 NET_6388 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M90 NET_6378 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M91 PAD NET_44 NET_6396 NET_1325 P33 l=0.300u w=30.000u
M92 NET_6396 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M93 VDD33 NET_52 NET_6394 NET_1325 P33 l=0.300u w=30.000u
M94 NET_6394 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M95 NET_6381 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M96 NET_73 NET_70 VDD33 VDD33 P33 l=0.300u w=5.000u
M97 NET_73 NET_70 VDD33 VDD33 P33 l=0.300u w=5.000u
M98 VDD33 NET_52 NET_6376 NET_1325 P33 l=0.300u w=30.000u
M99 NET_6376 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M100 NET_6366 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M101 NET_6366 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M102 VDD33 NET_52 NET_6379 NET_1325 P33 l=0.300u w=30.000u
M103 NET_6379 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M104 NET_6371 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M105 NET_6371 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M106 VDD33 NET_70 NET_73 VDD33 P33 l=0.300u w=5.000u
M107 VDD33 VSS NET_3484 VDD33 P33 l=0.300u w=5.000u
M108 VDD33 NET_78 NET_70 VDD33 P33 l=0.300u w=5.000u
M109 VDD33 NET_70 NET_78 VDD33 P33 l=0.300u w=5.000u
M110 VDD33 NET_52 NET_6364 NET_1325 P33 l=0.300u w=30.000u
M111 NET_6364 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M112 PAD NET_44 NET_6362 NET_1325 P33 l=0.300u w=30.000u
M113 NET_6362 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M114 NET_6344 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M115 VDD33 NET_52 NET_6369 NET_1325 P33 l=0.300u w=30.000u
M116 NET_6369 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M117 PAD NET_44 NET_6367 NET_1325 P33 l=0.300u w=30.000u
M118 NET_6367 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M119 NET_6348 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M120 PAD NET_44 NET_6342 NET_1325 P33 l=0.300u w=30.000u
M121 NET_6342 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M122 PAD NET_44 NET_6346 NET_1325 P33 l=0.300u w=30.000u
M123 NET_6346 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M124 NET_1325 PAD VDD33 NET_1325 P33 l=0.350u w=5.000u
M125 NET_1325 PAD VDD33 NET_1325 P33 l=0.350u w=5.000u
M126 VDD33 PAD NET_1325 NET_1325 P33 l=0.350u w=5.000u
M127 NET_52 NET_55 VDD33 VDD33 P33 l=0.300u w=5.000u
M128 NET_52 NET_55 VDD33 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_55 NET_52 VDD33 P33 l=0.300u w=5.000u
M130 NET_52 NET_55 VDD33 VDD33 P33 l=0.300u w=5.000u
M131 VDD33 NET_55 NET_52 VDD33 P33 l=0.300u w=5.000u
M132 VDD33 NET_55 NET_56 VDD33 P33 l=0.300u w=5.000u
M133 VDD33 NET_56 NET_55 VDD33 P33 l=0.300u w=5.000u
M134 PAD VDD33 NET_44 NET_1325 P33 l=0.350u w=10.000u
M135 PAD VDD33 NET_1325 NET_1325 P33 l=0.350u w=15.000u
M136 NET_6378 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M137 NET_6344 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
M138 NET_6381 NET_52 VDD33 NET_1325 P33 l=0.300u w=30.000u
M139 NET_6348 NET_44 PAD NET_1325 P33 l=0.300u w=30.000u
.ends PO24

.subckt PO2   PAD I FP
M1 VSS NET_58 NET_54 VSS N18 l=0.180u w=4.000u
M2 VSS NET_58 NET_54 VSS N18 l=0.180u w=4.000u
M3 NET_59 I VSS VSS N18 l=0.180u w=4.000u
M4 NET_59 VDD NET_58 VSS N18 l=0.180u w=4.000u
M5 VSS VSS NET_63 VSS N18 l=0.180u w=2.000u
M6 VSS VSS NET_63 VSS N18 l=0.180u w=2.000u
M7 NET_63 I VSS VSS N18 l=0.180u w=2.000u
M8 VSS I NET_63 VSS N18 l=0.180u w=2.000u
M9 VSS NET_63 NET_43 VSS N18 l=0.180u w=2.000u
M10 VSS NET_63 NET_43 VSS N18 l=0.180u w=2.000u
M11 VDD NET_63 NET_43 VDD P18 l=0.180u w=5.000u
M12 VDD NET_63 NET_43 VDD P18 l=0.180u w=5.000u
M13 NET_43 NET_63 VDD VDD P18 l=0.180u w=5.000u
M14 VDD NET_63 NET_43 VDD P18 l=0.180u w=5.000u
M15 NET_6305 VSS NET_63 VDD P18 l=0.180u w=5.000u
M16 NET_6305 I VDD VDD P18 l=0.180u w=5.000u
M17 NET_58 I VDD VDD P18 l=0.180u w=5.000u
M18 NET_58 I VDD VDD P18 l=0.180u w=5.000u
M19 VDD VDD NET_58 VDD P18 l=0.180u w=5.000u
M20 NET_58 VDD VDD VDD P18 l=0.180u w=5.000u
M21 VDD NET_58 NET_54 VDD P18 l=0.180u w=5.000u
M22 VDD NET_58 NET_54 VDD P18 l=0.180u w=5.000u
M23 NET_74 NET_43 VSS VSS N33 l=0.350u w=8.000u
M24 NET_74 NET_43 VSS VSS N33 l=0.350u w=8.000u
M25 VSS NET_63 NET_69 VSS N33 l=0.350u w=8.000u
M26 VSS NET_63 NET_69 VSS N33 l=0.350u w=8.000u
M27 NET_62 NET_3491 NET_60 VSS N33 l=0.350u w=8.000u
M28 NET_62 VDD33 VSS VSS N33 l=0.350u w=8.000u
M29 VSS NET_69 NET_75 VSS N33 l=0.350u w=4.000u
M30 VSS NET_69 NET_75 VSS N33 l=0.350u w=4.000u
M31 VSS NET_58 NET_44 VSS N33 l=0.350u w=5.330u
M32 VSS NET_58 NET_44 VSS N33 l=0.350u w=5.330u
M33 NET_44 NET_58 VSS VSS N33 l=0.350u w=5.330u
M34 VSS NET_54 NET_45 VSS N33 l=0.350u w=5.330u
M35 NET_45 NET_54 VSS VSS N33 l=0.350u w=5.330u
M36 VSS NET_54 NET_45 VSS N33 l=0.350u w=5.330u
M37 VSS NET_44 NET_51 VSS N33 l=0.350u w=4.000u
M38 VSS NET_44 NET_51 VSS N33 l=0.350u w=4.000u
M39 NET_39 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M40 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M41 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M42 NET_30 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M43 VSSD NET_23 NET_28 VSSD N33 l=0.400u w=28.000u
M44 NET_28 FP PAD VSSD N33 l=0.400u w=28.000u
M45 PAD FP NET_26 VSSD N33 l=0.400u w=28.000u
M46 NET_26 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_23 NET_24 VSSD N33 l=0.400u w=28.000u
M48 NET_24 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_15 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_23 NET_13 VSSD N33 l=0.400u w=28.000u
M52 NET_13 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_11 VSSD N33 l=0.400u w=28.000u
M54 NET_11 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_41 NET_75 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_37 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_23 NET_35 VSSD N33 l=0.400u w=28.000u
M60 NET_35 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_33 VSSD N33 l=0.400u w=28.000u
M62 NET_33 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_23 NET_31 VSSD N33 l=0.400u w=28.000u
M64 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_21 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_23 NET_19 VSSD N33 l=0.400u w=28.000u
M68 NET_19 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_17 VSSD N33 l=0.400u w=28.000u
M70 NET_17 NET_23 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_23 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_1324 NET_1324 NET_1324 NET_1324 P33 l=1.070u w=5.000u
M73 NET_6375 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M74 NET_6375 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M75 NET_6378 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M76 NET_6378 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M77 PAD NET_60 NET_6311 NET_1324 P33 l=0.300u w=30.000u
M78 VDD33 NET_3491 NET_6311 NET_1324 P33 l=0.300u w=30.000u
M79 VDD33 NET_3491 NET_6363 NET_1324 P33 l=0.300u w=30.000u
M80 NET_6363 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M81 PAD NET_60 NET_6313 NET_1324 P33 l=0.300u w=30.000u
M82 VDD33 NET_3491 NET_6313 NET_1324 P33 l=0.300u w=30.000u
M83 VDD33 NET_3491 NET_6369 NET_1324 P33 l=0.300u w=30.000u
M84 NET_6369 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M85 VDD33 NET_69 NET_75 VDD33 P33 l=0.300u w=5.000u
M86 PAD NET_60 NET_6361 NET_1324 P33 l=0.300u w=30.000u
M87 NET_6361 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M88 VDD33 NET_3491 NET_6359 NET_1324 P33 l=0.300u w=30.000u
M89 NET_6359 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M90 NET_6355 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M91 PAD NET_60 NET_6367 NET_1324 P33 l=0.300u w=30.000u
M92 NET_6367 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M93 VDD33 NET_3491 NET_6365 NET_1324 P33 l=0.300u w=30.000u
M94 NET_6365 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M95 NET_6358 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M96 VDD33 NET_74 NET_69 VDD33 P33 l=0.300u w=5.000u
M97 VDD33 NET_69 NET_74 VDD33 P33 l=0.300u w=5.000u
M98 VDD33 VSS NET_3491 VDD33 P33 l=0.300u w=5.000u
M99 VDD33 NET_3491 NET_6353 NET_1324 P33 l=0.300u w=30.000u
M100 NET_6353 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M101 NET_6341 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M102 NET_6341 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M103 VDD33 NET_3491 NET_6356 NET_1324 P33 l=0.300u w=30.000u
M104 NET_6356 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M105 NET_6346 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M106 NET_6346 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M107 VDD33 NET_3491 NET_6339 NET_1324 P33 l=0.300u w=30.000u
M108 NET_6339 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M109 PAD NET_60 NET_6337 NET_1324 P33 l=0.300u w=30.000u
M110 NET_6337 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M111 NET_6326 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M112 VDD33 NET_3491 NET_6344 NET_1324 P33 l=0.300u w=30.000u
M113 NET_6344 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M114 PAD NET_60 NET_6342 NET_1324 P33 l=0.300u w=30.000u
M115 NET_6342 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M116 NET_6330 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M117 VDD33 NET_44 NET_45 VDD33 P33 l=0.300u w=5.000u
M118 VDD33 NET_45 NET_44 VDD33 P33 l=0.300u w=5.000u
M119 NET_51 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M120 NET_51 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M121 VDD33 NET_44 NET_51 VDD33 P33 l=0.300u w=5.000u
M122 PAD NET_60 NET_6324 NET_1324 P33 l=0.300u w=30.000u
M123 NET_6324 NET_51 VDD33 NET_1324 P33 l=0.300u w=30.000u
M124 PAD NET_60 NET_6328 NET_1324 P33 l=0.300u w=30.000u
M125 NET_6328 NET_51 VDD33 NET_1324 P33 l=0.300u w=30.000u
M126 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M127 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M128 VDD33 PAD NET_1324 NET_1324 P33 l=0.350u w=5.000u
M129 PAD VDD33 NET_60 NET_1324 P33 l=0.350u w=10.000u
M130 PAD VDD33 NET_1324 NET_1324 P33 l=0.350u w=15.000u
M131 NET_6355 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M132 NET_6326 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
M133 NET_6358 NET_3491 VDD33 NET_1324 P33 l=0.300u w=30.000u
M134 NET_6330 NET_60 PAD NET_1324 P33 l=0.300u w=30.000u
.ends PO2

.subckt PO16   PAD I FP
M1 VSS VSS NET_64 VSS N18 l=0.180u w=2.000u
M2 VSS VSS NET_64 VSS N18 l=0.180u w=2.000u
M3 NET_64 I VSS VSS N18 l=0.180u w=2.000u
M4 VSS I NET_64 VSS N18 l=0.180u w=2.000u
M5 VSS NET_64 NET_60 VSS N18 l=0.180u w=2.000u
M6 VSS NET_64 NET_60 VSS N18 l=0.180u w=2.000u
M7 VSS NET_73 NET_69 VSS N18 l=0.180u w=4.000u
M8 VSS NET_73 NET_69 VSS N18 l=0.180u w=4.000u
M9 NET_74 I VSS VSS N18 l=0.180u w=4.000u
M10 NET_74 VDD NET_73 VSS N18 l=0.180u w=4.000u
M11 NET_6335 VSS NET_64 VDD P18 l=0.180u w=5.000u
M12 NET_6335 I VDD VDD P18 l=0.180u w=5.000u
M13 VDD NET_64 NET_60 VDD P18 l=0.180u w=5.000u
M14 VDD NET_64 NET_60 VDD P18 l=0.180u w=5.000u
M15 NET_60 NET_64 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_64 NET_60 VDD P18 l=0.180u w=5.000u
M17 NET_73 I VDD VDD P18 l=0.180u w=5.000u
M18 NET_73 I VDD VDD P18 l=0.180u w=5.000u
M19 VDD NET_73 NET_69 VDD P18 l=0.180u w=5.000u
M20 VDD NET_73 NET_69 VDD P18 l=0.180u w=5.000u
M21 VDD VDD NET_73 VDD P18 l=0.180u w=5.000u
M22 NET_73 VDD VDD VDD P18 l=0.180u w=5.000u
M23 VSS NET_19 NET_20 VSS N33 l=0.350u w=8.000u
M24 VSS NET_19 NET_20 VSS N33 l=0.350u w=8.000u
M25 NET_63 NET_3486 NET_61 VSS N33 l=0.350u w=8.000u
M26 NET_63 VDD33 VSS VSS N33 l=0.350u w=8.000u
M27 NET_25 NET_60 VSS VSS N33 l=0.350u w=8.000u
M28 NET_25 NET_60 VSS VSS N33 l=0.350u w=8.000u
M29 VSS NET_64 NET_19 VSS N33 l=0.350u w=8.000u
M30 VSS NET_64 NET_19 VSS N33 l=0.350u w=8.000u
M31 VSS NET_12 NET_9 VSS N33 l=0.350u w=10.000u
M32 VSS NET_12 NET_9 VSS N33 l=0.350u w=10.000u
M33 VSS NET_73 NET_12 VSS N33 l=0.350u w=5.330u
M34 VSS NET_73 NET_12 VSS N33 l=0.350u w=5.330u
M35 NET_12 NET_73 VSS VSS N33 l=0.350u w=5.330u
M36 VSS NET_69 NET_13 VSS N33 l=0.350u w=5.330u
M37 NET_13 NET_69 VSS VSS N33 l=0.350u w=5.330u
M38 VSS NET_69 NET_13 VSS N33 l=0.350u w=5.330u
M39 NET_57 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M40 NET_57 FP PAD VSSD N33 l=0.400u w=28.000u
M41 NET_48 FP PAD VSSD N33 l=0.400u w=28.000u
M42 NET_48 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M43 VSSD NET_20 NET_46 VSSD N33 l=0.400u w=28.000u
M44 NET_46 FP PAD VSSD N33 l=0.400u w=28.000u
M45 PAD FP NET_44 VSSD N33 l=0.400u w=28.000u
M46 NET_44 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_41 NET_42 VSSD N33 l=0.400u w=28.000u
M48 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_33 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_41 NET_31 VSSD N33 l=0.400u w=28.000u
M52 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_29 VSSD N33 l=0.400u w=28.000u
M54 NET_29 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_59 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_59 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_55 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_55 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_20 NET_53 VSSD N33 l=0.400u w=28.000u
M60 NET_53 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_51 VSSD N33 l=0.400u w=28.000u
M62 NET_51 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_41 NET_49 VSSD N33 l=0.400u w=28.000u
M64 NET_49 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_39 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_41 NET_37 VSSD N33 l=0.400u w=28.000u
M68 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M70 NET_35 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_41 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_6403 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M73 NET_6403 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M74 NET_6405 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M75 NET_6405 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M76 NET_1324 NET_1324 NET_1324 NET_1324 P33 l=1.070u w=5.000u
M77 PAD NET_61 NET_6322 NET_1324 P33 l=0.300u w=30.000u
M78 VDD33 NET_3486 NET_6322 NET_1324 P33 l=0.300u w=30.000u
M79 VDD33 NET_3486 NET_6392 NET_1324 P33 l=0.300u w=30.000u
M80 NET_6392 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M81 PAD NET_61 NET_6323 NET_1324 P33 l=0.300u w=30.000u
M82 VDD33 NET_3486 NET_6323 NET_1324 P33 l=0.300u w=30.000u
M83 VDD33 NET_3486 NET_6398 NET_1324 P33 l=0.300u w=30.000u
M84 NET_6398 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M85 PAD NET_61 NET_6390 NET_1324 P33 l=0.300u w=30.000u
M86 NET_6390 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M87 VDD33 NET_9 NET_6388 NET_1324 P33 l=0.300u w=30.000u
M88 NET_6388 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M89 NET_6377 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M90 PAD NET_61 NET_6396 NET_1324 P33 l=0.300u w=30.000u
M91 NET_6396 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M92 VDD33 NET_9 NET_6394 NET_1324 P33 l=0.300u w=30.000u
M93 NET_6394 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M94 NET_6380 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M95 NET_20 NET_19 VDD33 VDD33 P33 l=0.300u w=5.000u
M96 NET_20 NET_19 VDD33 VDD33 P33 l=0.300u w=5.000u
M97 VDD33 NET_9 NET_6375 NET_1324 P33 l=0.300u w=30.000u
M98 NET_6375 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M99 NET_6365 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M100 NET_6365 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M101 VDD33 NET_9 NET_6378 NET_1324 P33 l=0.300u w=30.000u
M102 NET_6378 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M103 NET_6370 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M104 NET_6370 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M105 VDD33 NET_19 NET_20 VDD33 P33 l=0.300u w=5.000u
M106 NET_20 NET_19 VDD33 VDD33 P33 l=0.300u w=5.000u
M107 VDD33 VSS NET_3486 VDD33 P33 l=0.300u w=5.000u
M108 VDD33 NET_25 NET_19 VDD33 P33 l=0.300u w=5.000u
M109 VDD33 NET_19 NET_25 VDD33 P33 l=0.300u w=5.000u
M110 VDD33 NET_9 NET_6363 NET_1324 P33 l=0.300u w=30.000u
M111 NET_6363 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M112 PAD NET_61 NET_6361 NET_1324 P33 l=0.300u w=30.000u
M113 NET_6361 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M114 NET_6345 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M115 VDD33 NET_9 NET_6368 NET_1324 P33 l=0.300u w=30.000u
M116 NET_6368 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M117 PAD NET_61 NET_6366 NET_1324 P33 l=0.300u w=30.000u
M118 NET_6366 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M119 NET_6349 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M120 PAD NET_61 NET_6343 NET_1324 P33 l=0.300u w=30.000u
M121 NET_6343 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M122 PAD NET_61 NET_6347 NET_1324 P33 l=0.300u w=30.000u
M123 NET_6347 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M124 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M125 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M126 VDD33 PAD NET_1324 NET_1324 P33 l=0.350u w=5.000u
M127 NET_9 NET_12 VDD33 VDD33 P33 l=0.300u w=5.000u
M128 NET_9 NET_12 VDD33 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_12 NET_9 VDD33 P33 l=0.300u w=5.000u
M130 VDD33 NET_12 NET_13 VDD33 P33 l=0.300u w=5.000u
M131 VDD33 NET_13 NET_12 VDD33 P33 l=0.300u w=5.000u
M132 PAD VDD33 NET_61 NET_1324 P33 l=0.350u w=10.000u
M133 PAD VDD33 NET_1324 NET_1324 P33 l=0.350u w=15.000u
M134 NET_6377 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M135 NET_6345 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M136 NET_6380 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M137 NET_6349 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
.ends PO16

.subckt PO12   PAD I FP
M1 VSS VSS NET_64 VSS N18 l=0.180u w=2.000u
M2 VSS VSS NET_64 VSS N18 l=0.180u w=2.000u
M3 NET_64 I VSS VSS N18 l=0.180u w=2.000u
M4 VSS I NET_64 VSS N18 l=0.180u w=2.000u
M5 VSS NET_64 NET_60 VSS N18 l=0.180u w=2.000u
M6 VSS NET_64 NET_60 VSS N18 l=0.180u w=2.000u
M7 VSS NET_73 NET_69 VSS N18 l=0.180u w=4.000u
M8 VSS NET_73 NET_69 VSS N18 l=0.180u w=4.000u
M9 NET_74 I VSS VSS N18 l=0.180u w=4.000u
M10 NET_74 VDD NET_73 VSS N18 l=0.180u w=4.000u
M11 NET_6335 VSS NET_64 VDD P18 l=0.180u w=5.000u
M12 NET_6335 I VDD VDD P18 l=0.180u w=5.000u
M13 VDD NET_64 NET_60 VDD P18 l=0.180u w=5.000u
M14 VDD NET_64 NET_60 VDD P18 l=0.180u w=5.000u
M15 NET_60 NET_64 VDD VDD P18 l=0.180u w=5.000u
M16 VDD NET_64 NET_60 VDD P18 l=0.180u w=5.000u
M17 NET_73 I VDD VDD P18 l=0.180u w=5.000u
M18 NET_73 I VDD VDD P18 l=0.180u w=5.000u
M19 VDD NET_73 NET_69 VDD P18 l=0.180u w=5.000u
M20 VDD NET_73 NET_69 VDD P18 l=0.180u w=5.000u
M21 VDD VDD NET_73 VDD P18 l=0.180u w=5.000u
M22 NET_73 VDD VDD VDD P18 l=0.180u w=5.000u
M23 VSS NET_19 NET_20 VSS N33 l=0.350u w=8.000u
M24 VSS NET_19 NET_20 VSS N33 l=0.350u w=8.000u
M25 NET_63 NET_3486 NET_61 VSS N33 l=0.350u w=8.000u
M26 NET_63 VDD33 VSS VSS N33 l=0.350u w=8.000u
M27 NET_25 NET_60 VSS VSS N33 l=0.350u w=8.000u
M28 NET_25 NET_60 VSS VSS N33 l=0.350u w=8.000u
M29 VSS NET_64 NET_19 VSS N33 l=0.350u w=8.000u
M30 VSS NET_64 NET_19 VSS N33 l=0.350u w=8.000u
M31 VSS NET_12 NET_9 VSS N33 l=0.350u w=10.000u
M32 VSS NET_12 NET_9 VSS N33 l=0.350u w=10.000u
M33 VSS NET_73 NET_12 VSS N33 l=0.350u w=5.330u
M34 VSS NET_73 NET_12 VSS N33 l=0.350u w=5.330u
M35 NET_12 NET_73 VSS VSS N33 l=0.350u w=5.330u
M36 VSS NET_69 NET_13 VSS N33 l=0.350u w=5.330u
M37 NET_13 NET_69 VSS VSS N33 l=0.350u w=5.330u
M38 VSS NET_69 NET_13 VSS N33 l=0.350u w=5.330u
M39 NET_57 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M40 NET_57 FP PAD VSSD N33 l=0.400u w=28.000u
M41 NET_48 FP PAD VSSD N33 l=0.400u w=28.000u
M42 NET_48 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M43 VSSD NET_20 NET_46 VSSD N33 l=0.400u w=28.000u
M44 NET_46 FP PAD VSSD N33 l=0.400u w=28.000u
M45 PAD FP NET_44 VSSD N33 l=0.400u w=28.000u
M46 NET_44 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_41 NET_42 VSSD N33 l=0.400u w=28.000u
M48 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_33 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_41 NET_31 VSSD N33 l=0.400u w=28.000u
M52 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_29 VSSD N33 l=0.400u w=28.000u
M54 NET_29 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_59 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_59 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_55 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_55 NET_20 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_20 NET_53 VSSD N33 l=0.400u w=28.000u
M60 NET_53 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_51 VSSD N33 l=0.400u w=28.000u
M62 NET_51 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_41 NET_49 VSSD N33 l=0.400u w=28.000u
M64 NET_49 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_39 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_41 NET_37 VSSD N33 l=0.400u w=28.000u
M68 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M70 NET_35 NET_41 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_41 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_6403 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M73 NET_6403 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M74 NET_6405 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M75 NET_6405 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M76 NET_1324 NET_1324 NET_1324 NET_1324 P33 l=1.070u w=5.000u
M77 PAD NET_61 NET_6322 NET_1324 P33 l=0.300u w=30.000u
M78 VDD33 NET_3486 NET_6322 NET_1324 P33 l=0.300u w=30.000u
M79 VDD33 NET_3486 NET_6392 NET_1324 P33 l=0.300u w=30.000u
M80 NET_6392 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M81 PAD NET_61 NET_6323 NET_1324 P33 l=0.300u w=30.000u
M82 VDD33 NET_3486 NET_6323 NET_1324 P33 l=0.300u w=30.000u
M83 VDD33 NET_3486 NET_6398 NET_1324 P33 l=0.300u w=30.000u
M84 NET_6398 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M85 PAD NET_61 NET_6390 NET_1324 P33 l=0.300u w=30.000u
M86 NET_6390 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M87 VDD33 NET_3486 NET_6388 NET_1324 P33 l=0.300u w=30.000u
M88 NET_6388 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M89 NET_6377 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M90 PAD NET_61 NET_6396 NET_1324 P33 l=0.300u w=30.000u
M91 NET_6396 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M92 VDD33 NET_3486 NET_6394 NET_1324 P33 l=0.300u w=30.000u
M93 NET_6394 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M94 NET_6380 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M95 NET_20 NET_19 VDD33 VDD33 P33 l=0.300u w=5.000u
M96 NET_20 NET_19 VDD33 VDD33 P33 l=0.300u w=5.000u
M97 VDD33 NET_9 NET_6375 NET_1324 P33 l=0.300u w=30.000u
M98 NET_6375 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M99 NET_6365 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M100 NET_6365 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M101 VDD33 NET_9 NET_6378 NET_1324 P33 l=0.300u w=30.000u
M102 NET_6378 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M103 NET_6370 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M104 NET_6370 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M105 VDD33 NET_19 NET_20 VDD33 P33 l=0.300u w=5.000u
M106 NET_20 NET_19 VDD33 VDD33 P33 l=0.300u w=5.000u
M107 VDD33 VSS NET_3486 VDD33 P33 l=0.300u w=5.000u
M108 VDD33 NET_25 NET_19 VDD33 P33 l=0.300u w=5.000u
M109 VDD33 NET_19 NET_25 VDD33 P33 l=0.300u w=5.000u
M110 VDD33 NET_9 NET_6363 NET_1324 P33 l=0.300u w=30.000u
M111 NET_6363 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M112 PAD NET_61 NET_6361 NET_1324 P33 l=0.300u w=30.000u
M113 NET_6361 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M114 NET_6345 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M115 VDD33 NET_9 NET_6368 NET_1324 P33 l=0.300u w=30.000u
M116 NET_6368 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M117 PAD NET_61 NET_6366 NET_1324 P33 l=0.300u w=30.000u
M118 NET_6366 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M119 NET_6349 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M120 PAD NET_61 NET_6343 NET_1324 P33 l=0.300u w=30.000u
M121 NET_6343 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M122 PAD NET_61 NET_6347 NET_1324 P33 l=0.300u w=30.000u
M123 NET_6347 NET_9 VDD33 NET_1324 P33 l=0.300u w=30.000u
M124 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M125 NET_1324 PAD VDD33 NET_1324 P33 l=0.350u w=5.000u
M126 VDD33 PAD NET_1324 NET_1324 P33 l=0.350u w=5.000u
M127 NET_9 NET_12 VDD33 VDD33 P33 l=0.300u w=5.000u
M128 NET_9 NET_12 VDD33 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_12 NET_9 VDD33 P33 l=0.300u w=5.000u
M130 VDD33 NET_12 NET_13 VDD33 P33 l=0.300u w=5.000u
M131 VDD33 NET_13 NET_12 VDD33 P33 l=0.300u w=5.000u
M132 PAD VDD33 NET_61 NET_1324 P33 l=0.350u w=10.000u
M133 PAD VDD33 NET_1324 NET_1324 P33 l=0.350u w=15.000u
M134 NET_6377 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M135 NET_6345 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
M136 NET_6380 NET_3486 VDD33 NET_1324 P33 l=0.300u w=30.000u
M137 NET_6349 NET_61 PAD NET_1324 P33 l=0.300u w=30.000u
.ends PO12

.subckt PBUL8   PAD OEN I C FP
M1 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M3 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M5 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M8 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M21 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M24 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M25 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M27 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 NET_5995 OEN NET_74 VDD P18 l=0.180u w=5.000u
M33 NET_5995 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M36 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M37 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M38 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M41 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M43 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M47 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M48 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M49 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_38 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M54 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M56 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M57 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M60 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M61 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M62 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M63 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M68 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M70 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_41 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M74 NET_43 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M77 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M78 NET_88 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M79 VSS NET_88 NET_92 VSS N33 l=0.350u w=8.000u
M80 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M81 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M82 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M83 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M84 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M85 NET_48 NET_49 VSS VSS N33 l=0.350u w=4.600u
M86 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M87 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M88 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M90 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M91 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M92 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M93 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M94 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M95 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M96 NET_63 NET_3497 NET_61 VSS N33 l=0.350u w=8.000u
M97 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M98 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M99 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M100 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M101 NET_5963 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M102 NET_5963 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M103 NET_5965 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M104 NET_5965 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M105 VDD33 VDD NET_44 NET_1360 P33 l=1.070u w=5.000u
M106 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M107 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M108 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M109 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M110 NET_92 NET_88 NET_3546 VDD33 P33 l=0.300u w=5.000u
M111 NET_92 NET_88 NET_3546 VDD33 P33 l=0.300u w=5.000u
M112 NET_3546 NET_88 NET_92 VDD33 P33 l=0.300u w=5.000u
M113 NET_92 NET_88 NET_3546 VDD33 P33 l=0.300u w=5.000u
M114 NET_3546 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M115 VDD33 NET_44 NET_3546 VDD33 P33 l=0.300u w=5.000u
M116 NET_3546 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M117 PAD NET_61 NET_5956 NET_1360 P33 l=0.300u w=30.000u
M118 VDD33 NET_3497 NET_5956 NET_1360 P33 l=0.300u w=30.000u
M119 VDD33 NET_3497 NET_5954 NET_1360 P33 l=0.300u w=30.000u
M120 NET_5954 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M121 PAD NET_61 NET_5961 NET_1360 P33 l=0.300u w=30.000u
M122 VDD33 NET_3497 NET_5961 NET_1360 P33 l=0.300u w=30.000u
M123 VDD33 NET_3497 NET_5959 NET_1360 P33 l=0.300u w=30.000u
M124 NET_5959 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M125 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M126 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M127 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M129 PAD NET_61 NET_5952 NET_1360 P33 l=0.300u w=30.000u
M130 PAD NET_61 NET_5957 NET_1360 P33 l=0.300u w=30.000u
M131 NET_85 NET_46 VDD33 VDD33 P33 l=0.300u w=5.000u
M132 NET_5946 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M133 NET_5946 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M134 PAD NET_61 NET_5944 NET_1360 P33 l=0.300u w=30.000u
M135 NET_5951 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M136 NET_5951 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M137 PAD NET_61 NET_5949 NET_1360 P33 l=0.300u w=30.000u
M138 NET_5952 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M139 NET_5957 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M140 VDD33 NET_3497 NET_5942 NET_1360 P33 l=0.300u w=30.000u
M141 NET_5942 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M142 VDD33 NET_3497 NET_5947 NET_1360 P33 l=0.300u w=30.000u
M143 NET_5947 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M144 VDD33 VSS NET_3497 VDD33 P33 l=0.300u w=5.000u
M145 VDD33 NET_46 NET_84 VDD33 P33 l=0.300u w=5.000u
M146 NET_5932 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M147 NET_5932 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M148 NET_5937 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M149 NET_5937 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M150 NET_46 NET_84 VDD33 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_48 NET_5930 NET_1360 P33 l=0.300u w=30.000u
M154 NET_5930 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M155 PAD NET_61 NET_5928 NET_1360 P33 l=0.300u w=30.000u
M156 VDD33 NET_48 NET_5935 NET_1360 P33 l=0.300u w=30.000u
M157 NET_5935 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M158 PAD NET_61 NET_5933 NET_1360 P33 l=0.300u w=30.000u
M159 NET_5919 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M160 NET_5923 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M161 NET_5928 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M162 NET_5933 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M163 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M165 NET_48 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M169 PAD NET_61 NET_5917 NET_1360 P33 l=0.300u w=30.000u
M170 NET_5917 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M171 PAD NET_61 NET_5921 NET_1360 P33 l=0.300u w=30.000u
M172 NET_5921 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M173 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M174 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M175 VDD33 PAD NET_1360 NET_1360 P33 l=0.350u w=5.000u
M176 VDD33 NET_44 NET_3546 VDD33 P33 l=0.300u w=5.000u
M177 NET_5944 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M178 NET_5949 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M179 NET_5919 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M180 NET_5923 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_61 NET_1360 P33 l=0.350u w=10.000u
M182 PAD VDD33 NET_1360 NET_1360 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBUL8

.subckt PBUL24   PAD OEN I C FP
M1 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M3 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M5 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M8 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M21 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M24 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M25 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M27 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 NET_5993 OEN NET_74 VDD P18 l=0.180u w=5.000u
M33 NET_5993 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M36 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M37 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M38 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M41 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M43 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_85 NET_29 VSSD N33 l=0.400u w=28.000u
M47 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M48 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M49 NET_27 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_38 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_85 NET_36 VSSD N33 l=0.400u w=28.000u
M54 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M56 NET_34 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M57 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_16 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M60 VSSD NET_85 NET_14 VSSD N33 l=0.400u w=28.000u
M61 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M62 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M63 NET_12 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M64 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M68 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M70 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_41 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_85 NET_25 VSSD N33 l=0.400u w=28.000u
M74 NET_43 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M77 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M78 NET_88 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M79 VSS NET_88 NET_92 VSS N33 l=0.350u w=8.000u
M80 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M81 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M82 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M83 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M84 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M85 NET_48 NET_49 VSS VSS N33 l=0.350u w=4.400u
M86 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M87 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M88 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M90 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M91 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M92 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M93 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M94 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M95 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M96 NET_63 NET_3497 NET_61 VSS N33 l=0.350u w=8.000u
M97 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M98 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M99 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M100 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M101 NET_5961 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M102 NET_5961 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M103 NET_5963 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M104 NET_5963 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M105 VDD33 VDD NET_44 NET_1360 P33 l=1.070u w=5.000u
M106 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M107 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M108 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M109 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M110 PAD NET_61 NET_5954 NET_1360 P33 l=0.300u w=30.000u
M111 VDD33 NET_48 NET_5954 NET_1360 P33 l=0.300u w=30.000u
M112 VDD33 NET_48 NET_5952 NET_1360 P33 l=0.300u w=30.000u
M113 NET_5952 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M114 PAD NET_61 NET_5959 NET_1360 P33 l=0.300u w=30.000u
M115 VDD33 NET_48 NET_5959 NET_1360 P33 l=0.300u w=30.000u
M116 VDD33 NET_48 NET_5957 NET_1360 P33 l=0.300u w=30.000u
M117 NET_5957 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M118 NET_92 NET_88 NET_3544 VDD33 P33 l=0.300u w=5.000u
M119 NET_92 NET_88 NET_3544 VDD33 P33 l=0.300u w=5.000u
M120 NET_3544 NET_88 NET_92 VDD33 P33 l=0.300u w=5.000u
M121 NET_92 NET_88 NET_3544 VDD33 P33 l=0.300u w=5.000u
M122 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M124 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M126 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M127 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M129 PAD NET_61 NET_5950 NET_1360 P33 l=0.300u w=30.000u
M130 PAD NET_61 NET_5955 NET_1360 P33 l=0.300u w=30.000u
M131 NET_5944 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M132 NET_5944 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M133 PAD NET_61 NET_5942 NET_1360 P33 l=0.300u w=30.000u
M134 NET_5949 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M135 NET_5949 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M136 PAD NET_61 NET_5947 NET_1360 P33 l=0.300u w=30.000u
M137 VDD33 NET_46 NET_85 VDD33 P33 l=0.300u w=4.600u
M138 NET_5950 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M139 NET_5955 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M140 VDD33 NET_48 NET_5940 NET_1360 P33 l=0.300u w=30.000u
M141 NET_5940 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M142 VDD33 NET_48 NET_5945 NET_1360 P33 l=0.300u w=30.000u
M143 NET_5945 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M144 NET_5930 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M145 NET_5930 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M146 NET_5935 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M147 NET_5935 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3497 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_46 NET_84 VDD33 P33 l=0.300u w=5.000u
M150 NET_46 NET_84 VDD33 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_48 NET_5928 NET_1360 P33 l=0.300u w=30.000u
M152 NET_5928 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M153 PAD NET_61 NET_5926 NET_1360 P33 l=0.300u w=30.000u
M154 VDD33 NET_48 NET_5933 NET_1360 P33 l=0.300u w=30.000u
M155 NET_5933 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M156 PAD NET_61 NET_5931 NET_1360 P33 l=0.300u w=30.000u
M157 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M158 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M159 NET_5917 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M160 NET_5921 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M161 NET_5926 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M162 NET_5931 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M163 PAD NET_61 NET_5915 NET_1360 P33 l=0.300u w=30.000u
M164 NET_5915 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M165 PAD NET_61 NET_5919 NET_1360 P33 l=0.300u w=30.000u
M166 NET_5919 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M167 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M168 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M169 VDD33 PAD NET_1360 NET_1360 P33 l=0.350u w=5.000u
M170 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M172 NET_48 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M177 NET_5942 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M178 NET_5947 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M179 NET_5917 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M180 NET_5921 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_61 NET_1360 P33 l=0.350u w=10.000u
M182 PAD VDD33 NET_1360 NET_1360 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBUL24

.subckt PBUL16   PAD OEN I C FP
M1 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M3 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M5 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M8 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M21 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M24 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M25 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M27 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 NET_5985 OEN NET_74 VDD P18 l=0.180u w=5.000u
M33 NET_5985 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M36 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M37 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M38 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M41 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M43 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_85 NET_29 VSSD N33 l=0.400u w=28.000u
M47 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M48 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M49 NET_27 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_38 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_85 NET_36 VSSD N33 l=0.400u w=28.000u
M54 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M56 NET_34 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M57 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M60 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M61 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M62 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M63 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M68 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M70 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_41 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M74 NET_43 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M77 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M78 NET_88 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M79 VSS NET_88 NET_92 VSS N33 l=0.350u w=8.000u
M80 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M81 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M82 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M83 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M84 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M85 NET_48 NET_49 VSS VSS N33 l=0.350u w=3.400u
M86 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M87 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M88 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M90 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M91 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M92 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M93 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M94 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M95 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M96 NET_63 NET_3497 NET_61 VSS N33 l=0.350u w=8.000u
M97 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M98 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M99 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M100 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M101 NET_5953 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M102 NET_5953 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M103 NET_5955 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M104 NET_5955 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M105 VDD33 VDD NET_44 NET_1360 P33 l=1.070u w=5.000u
M106 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M107 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M108 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M109 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M110 NET_92 NET_88 NET_3544 VDD33 P33 l=0.300u w=5.000u
M111 NET_92 NET_88 NET_3544 VDD33 P33 l=0.300u w=5.000u
M112 NET_3544 NET_88 NET_92 VDD33 P33 l=0.300u w=5.000u
M113 NET_92 NET_88 NET_3544 VDD33 P33 l=0.300u w=5.000u
M114 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M115 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M116 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M117 PAD NET_61 NET_5946 NET_1360 P33 l=0.300u w=30.000u
M118 VDD33 NET_3497 NET_5946 NET_1360 P33 l=0.300u w=30.000u
M119 VDD33 NET_3497 NET_5944 NET_1360 P33 l=0.300u w=30.000u
M120 NET_5944 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M121 PAD NET_61 NET_5951 NET_1360 P33 l=0.300u w=30.000u
M122 VDD33 NET_3497 NET_5951 NET_1360 P33 l=0.300u w=30.000u
M123 VDD33 NET_3497 NET_5949 NET_1360 P33 l=0.300u w=30.000u
M124 NET_5949 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M125 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M126 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M127 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M129 PAD NET_61 NET_5942 NET_1360 P33 l=0.300u w=30.000u
M130 PAD NET_61 NET_5947 NET_1360 P33 l=0.300u w=30.000u
M131 NET_85 NET_46 VDD33 VDD33 P33 l=0.300u w=3.600u
M132 NET_5936 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M133 NET_5936 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M134 PAD NET_61 NET_5934 NET_1360 P33 l=0.300u w=30.000u
M135 NET_5941 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M136 NET_5941 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M137 PAD NET_61 NET_5939 NET_1360 P33 l=0.300u w=30.000u
M138 NET_5942 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M139 NET_5947 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M140 VDD33 NET_48 NET_5932 NET_1360 P33 l=0.300u w=30.000u
M141 NET_5932 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M142 VDD33 NET_48 NET_5937 NET_1360 P33 l=0.300u w=30.000u
M143 NET_5937 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M144 VDD33 VSS NET_3497 VDD33 P33 l=0.300u w=5.000u
M145 VDD33 NET_46 NET_84 VDD33 P33 l=0.300u w=5.000u
M146 NET_5922 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M147 NET_5922 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M148 NET_5927 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M149 NET_5927 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M150 NET_46 NET_84 VDD33 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_48 NET_5920 NET_1360 P33 l=0.300u w=30.000u
M154 NET_5920 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M155 PAD NET_61 NET_5918 NET_1360 P33 l=0.300u w=30.000u
M156 VDD33 NET_48 NET_5925 NET_1360 P33 l=0.300u w=30.000u
M157 NET_5925 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M158 PAD NET_61 NET_5923 NET_1360 P33 l=0.300u w=30.000u
M159 NET_5909 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M160 NET_5913 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M161 NET_5918 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M162 NET_5923 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M163 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M165 NET_48 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M169 PAD NET_61 NET_5907 NET_1360 P33 l=0.300u w=30.000u
M170 NET_5907 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M171 PAD NET_61 NET_5911 NET_1360 P33 l=0.300u w=30.000u
M172 NET_5911 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M173 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M174 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M175 VDD33 PAD NET_1360 NET_1360 P33 l=0.350u w=5.000u
M176 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M177 NET_5934 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M178 NET_5939 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M179 NET_5909 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M180 NET_5913 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_61 NET_1360 P33 l=0.350u w=10.000u
M182 PAD VDD33 NET_1360 NET_1360 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBUL16

.subckt PBUL12   PAD OEN I C FP
M1 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M3 C NET_102 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M5 C NET_102 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_105 NET_102 VSS N18 l=0.180u w=2.000u
M8 VSS NET_105 NET_102 VSS N18 l=0.180u w=2.000u
M9 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M10 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_71 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_71 NET_72 NET_70 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M17 NET_75 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_75 VSS N18 l=0.180u w=2.000u
M19 VSS NET_75 NET_45 VSS N18 l=0.180u w=2.000u
M20 VSS NET_75 NET_45 VSS N18 l=0.180u w=2.000u
M21 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_105 NET_102 VDD P18 l=0.180u w=5.000u
M23 VDD NET_105 NET_102 VDD P18 l=0.180u w=5.000u
M24 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M25 C NET_102 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M27 C NET_102 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M32 NET_6018 OEN NET_75 VDD P18 l=0.180u w=5.000u
M33 NET_6018 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M35 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M36 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M37 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M38 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_72 NET_70 VDD P18 l=0.180u w=5.000u
M41 NET_70 NET_72 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_86 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_86 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M62 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M63 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M64 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M65 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M70 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M72 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M74 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_44 VDD33 NET_89 VSS N33 l=0.350u w=8.000u
M77 NET_44 VDD33 NET_89 VSS N33 l=0.350u w=8.000u
M78 NET_89 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M79 VSS NET_89 NET_93 VSS N33 l=0.350u w=8.000u
M80 VSS NET_93 NET_105 VSS N33 l=0.350u w=2.000u
M81 VSS NET_93 NET_105 VSS N33 l=0.350u w=2.000u
M82 NET_85 NET_45 VSS VSS N33 l=0.350u w=8.000u
M83 VSS NET_46 NET_86 VSS N33 l=0.350u w=8.000u
M84 VSS NET_46 NET_86 VSS N33 l=0.350u w=8.000u
M85 VSS NET_50 NET_47 VSS N33 l=0.350u w=5.000u
M86 VSS NET_50 NET_47 VSS N33 l=0.350u w=5.000u
M87 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M88 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M89 NET_50 NET_70 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M91 NET_51 NET_66 VSS VSS N33 l=0.350u w=5.330u
M92 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M93 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M94 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M95 VSS NET_72 NET_59 VSS N33 l=0.350u w=7.440u
M96 NET_59 NET_72 VSS VSS N33 l=0.350u w=7.440u
M97 NET_64 NET_3498 NET_62 VSS N33 l=0.350u w=8.000u
M98 NET_64 NET_61 VSS VSS N33 l=0.350u w=8.000u
M99 NET_85 NET_45 VSS VSS N33 l=0.350u w=8.000u
M100 NET_46 NET_75 VSS VSS N33 l=0.350u w=8.000u
M101 NET_46 NET_75 VSS VSS N33 l=0.350u w=8.000u
M102 NET_5986 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M103 NET_5986 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M104 NET_5988 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M105 NET_5988 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M106 VDD33 VDD NET_44 NET_1361 P33 l=1.070u w=5.000u
M107 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M108 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M109 NET_105 NET_93 VDD VDD P33 l=0.300u w=5.000u
M110 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M111 NET_93 NET_89 NET_3548 VDD33 P33 l=0.300u w=5.000u
M112 NET_93 NET_89 NET_3548 VDD33 P33 l=0.300u w=5.000u
M113 NET_3548 NET_89 NET_93 VDD33 P33 l=0.300u w=5.000u
M114 NET_93 NET_89 NET_3548 VDD33 P33 l=0.300u w=5.000u
M115 NET_3548 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_44 NET_3548 VDD33 P33 l=0.300u w=5.000u
M117 NET_3548 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M118 PAD NET_62 NET_5979 NET_1361 P33 l=0.300u w=30.000u
M119 VDD33 NET_3498 NET_5979 NET_1361 P33 l=0.300u w=30.000u
M120 VDD33 NET_3498 NET_5977 NET_1361 P33 l=0.300u w=30.000u
M121 NET_5977 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M122 PAD NET_62 NET_5984 NET_1361 P33 l=0.300u w=30.000u
M123 VDD33 NET_3498 NET_5984 NET_1361 P33 l=0.300u w=30.000u
M124 VDD33 NET_3498 NET_5982 NET_1361 P33 l=0.300u w=30.000u
M125 NET_5982 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M126 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M127 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M128 NET_105 NET_93 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M130 PAD NET_62 NET_5975 NET_1361 P33 l=0.300u w=30.000u
M131 PAD NET_62 NET_5980 NET_1361 P33 l=0.300u w=30.000u
M132 VDD33 NET_46 NET_86 VDD33 P33 l=0.300u w=4.800u
M133 VDD33 NET_46 NET_86 VDD33 P33 l=0.300u w=4.800u
M134 NET_5969 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M135 NET_5969 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M136 PAD NET_62 NET_5967 NET_1361 P33 l=0.300u w=30.000u
M137 NET_5974 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M138 NET_5974 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M139 PAD NET_62 NET_5972 NET_1361 P33 l=0.300u w=30.000u
M140 NET_5975 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M141 NET_5980 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M142 VDD33 NET_47 NET_5965 NET_1361 P33 l=0.300u w=30.000u
M143 NET_5965 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M144 VDD33 NET_47 NET_5970 NET_1361 P33 l=0.300u w=30.000u
M145 NET_5970 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M146 VDD33 VSS NET_3498 VDD33 P33 l=0.300u w=5.000u
M147 VDD33 NET_46 NET_85 VDD33 P33 l=0.300u w=5.000u
M148 NET_5955 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M149 NET_5955 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M150 NET_5960 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M151 NET_5960 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M152 NET_46 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_61 NET_59 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_59 NET_61 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_47 NET_5953 NET_1361 P33 l=0.300u w=30.000u
M156 NET_5953 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M157 PAD NET_62 NET_5951 NET_1361 P33 l=0.300u w=30.000u
M158 VDD33 NET_47 NET_5958 NET_1361 P33 l=0.300u w=30.000u
M159 NET_5958 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M160 PAD NET_62 NET_5956 NET_1361 P33 l=0.300u w=30.000u
M161 NET_5942 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M162 NET_5946 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M163 NET_5951 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M164 NET_5956 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M165 VDD33 NET_50 NET_47 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_50 NET_47 VDD33 P33 l=0.300u w=5.000u
M167 NET_47 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_50 NET_47 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_50 NET_51 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M171 PAD NET_62 NET_5940 NET_1361 P33 l=0.300u w=30.000u
M172 NET_5940 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M173 PAD NET_62 NET_5944 NET_1361 P33 l=0.300u w=30.000u
M174 NET_5944 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M175 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M176 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M177 VDD33 PAD NET_1361 NET_1361 P33 l=0.350u w=5.000u
M178 VDD33 NET_44 NET_3548 VDD33 P33 l=0.300u w=5.000u
M179 NET_5967 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M180 NET_5972 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M181 NET_5942 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M182 NET_5946 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_62 NET_1361 P33 l=0.350u w=10.000u
M184 PAD VDD33 NET_1361 NET_1361 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBUL12

.subckt PBU8   PAD OEN I C FP
M1 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M3 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M5 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M8 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M9 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M10 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_51 NET_52 NET_50 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M17 NET_55 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_55 VSS N18 l=0.180u w=2.000u
M19 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M20 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M21 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M23 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M24 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M25 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M27 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M32 NET_6041 OEN NET_55 VDD P18 l=0.180u w=5.000u
M33 NET_6041 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M35 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M36 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M37 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M38 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_52 NET_50 VDD P18 l=0.180u w=5.000u
M41 NET_50 NET_52 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M62 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M63 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M64 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M65 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M70 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M72 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M74 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M77 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M78 NET_103 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M79 VSS NET_103 NET_107 VSS N33 l=0.350u w=8.000u
M80 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M81 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M82 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M83 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M84 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M85 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M86 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M87 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M88 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M89 NET_67 NET_50 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M91 NET_68 NET_46 VSS VSS N33 l=0.350u w=5.330u
M92 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M93 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M94 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M95 VSS NET_52 NET_76 VSS N33 l=0.350u w=7.440u
M96 NET_76 NET_52 VSS VSS N33 l=0.350u w=7.440u
M97 NET_81 NET_3502 NET_79 VSS N33 l=0.350u w=8.000u
M98 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M99 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M100 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M101 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M102 NET_6010 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M103 NET_6010 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M104 NET_6012 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M105 NET_6012 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M106 VDD33 VDD NET_44 NET_1361 P33 l=1.070u w=5.000u
M107 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M108 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M109 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M110 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M111 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M112 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M113 NET_3544 NET_103 NET_107 VDD33 P33 l=0.300u w=5.000u
M114 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M115 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M117 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M118 PAD NET_79 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M119 VDD33 NET_3502 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M120 VDD33 NET_3502 NET_6001 NET_1361 P33 l=0.300u w=30.000u
M121 NET_6001 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M122 PAD NET_79 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M123 VDD33 NET_3502 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M124 VDD33 NET_3502 NET_6006 NET_1361 P33 l=0.300u w=30.000u
M125 NET_6006 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M126 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M127 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M128 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M130 PAD NET_79 NET_5999 NET_1361 P33 l=0.300u w=30.000u
M131 PAD NET_79 NET_6004 NET_1361 P33 l=0.300u w=30.000u
M132 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M133 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M134 NET_5993 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M135 NET_5993 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M136 PAD NET_79 NET_5991 NET_1361 P33 l=0.300u w=30.000u
M137 NET_5998 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M138 NET_5998 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M139 PAD NET_79 NET_5996 NET_1361 P33 l=0.300u w=30.000u
M140 NET_5999 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M141 NET_6004 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M142 VDD33 NET_82 NET_100 VDD33 P33 l=0.300u w=5.000u
M143 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M144 VDD33 NET_3502 NET_5989 NET_1361 P33 l=0.300u w=30.000u
M145 NET_5989 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M146 VDD33 NET_3502 NET_5994 NET_1361 P33 l=0.300u w=30.000u
M147 NET_5994 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3502 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_82 NET_99 VDD33 P33 l=0.300u w=5.000u
M150 NET_5979 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M151 NET_5979 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M152 NET_5984 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M153 NET_5984 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M154 NET_82 NET_99 VDD33 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M157 VDD33 NET_64 NET_5977 NET_1361 P33 l=0.300u w=30.000u
M158 NET_5977 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M159 PAD NET_79 NET_5975 NET_1361 P33 l=0.300u w=30.000u
M160 VDD33 NET_64 NET_5982 NET_1361 P33 l=0.300u w=30.000u
M161 NET_5982 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M162 PAD NET_79 NET_5980 NET_1361 P33 l=0.300u w=30.000u
M163 NET_5966 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M164 NET_5970 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M165 NET_5975 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M166 NET_5980 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M167 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M168 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M172 PAD NET_79 NET_5964 NET_1361 P33 l=0.300u w=30.000u
M173 NET_5964 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M174 PAD NET_79 NET_5968 NET_1361 P33 l=0.300u w=30.000u
M175 NET_5968 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M176 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M177 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M178 VDD33 PAD NET_1361 NET_1361 P33 l=0.350u w=5.000u
M179 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M180 NET_5991 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M181 NET_5996 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M182 NET_5966 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M183 NET_5970 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_79 NET_1361 P33 l=0.350u w=10.000u
M185 PAD VDD33 NET_1361 NET_1361 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBU8

.subckt PBU4   PAD OEN I C FP
M1 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M3 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M5 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_106 NET_103 VSS N18 l=0.180u w=2.000u
M8 VSS NET_106 NET_103 VSS N18 l=0.180u w=2.000u
M9 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M10 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M11 NET_69 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_69 NET_70 NET_68 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M17 NET_73 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_73 VSS N18 l=0.180u w=2.000u
M19 NET_78 NET_73 VSS VSS N18 l=0.180u w=2.000u
M20 VSS NET_73 NET_78 VSS N18 l=0.180u w=2.000u
M21 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_106 NET_103 VDD P18 l=0.180u w=5.000u
M23 VDD NET_106 NET_103 VDD P18 l=0.180u w=5.000u
M24 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M25 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M27 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M32 NET_6025 OEN NET_73 VDD P18 l=0.180u w=5.000u
M33 NET_6025 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M35 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M36 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M37 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M38 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_70 NET_68 VDD P18 l=0.180u w=5.000u
M41 NET_68 NET_70 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M60 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M64 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M66 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_44 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M77 NET_44 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M78 NET_90 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M79 VSS NET_90 NET_94 VSS N33 l=0.350u w=8.000u
M80 VSS NET_94 NET_106 VSS N33 l=0.350u w=2.000u
M81 VSS NET_94 NET_106 VSS N33 l=0.350u w=2.000u
M82 NET_85 NET_78 VSS VSS N33 l=0.350u w=8.000u
M83 NET_87 NET_10 VSS VSS N33 l=0.350u w=4.000u
M84 NET_87 NET_10 VSS VSS N33 l=0.350u w=4.000u
M85 VSS NET_10 NET_87 VSS N33 l=0.350u w=4.000u
M86 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M87 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M88 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M89 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M90 NET_48 NET_68 VSS VSS N33 l=0.350u w=5.330u
M91 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M92 NET_49 NET_64 VSS VSS N33 l=0.350u w=5.330u
M93 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M94 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M95 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M96 VSS NET_70 NET_57 VSS N33 l=0.350u w=7.440u
M97 NET_57 NET_70 VSS VSS N33 l=0.350u w=7.440u
M98 NET_62 NET_3512 NET_60 VSS N33 l=0.350u w=8.000u
M99 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M100 NET_85 NET_78 VSS VSS N33 l=0.350u w=8.000u
M101 VSS NET_73 NET_10 VSS N33 l=0.350u w=8.000u
M102 VSS NET_73 NET_10 VSS N33 l=0.350u w=8.000u
M103 NET_5995 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M104 NET_5995 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M105 NET_5997 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M106 NET_5997 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M107 VDD33 VDD NET_44 NET_1362 P33 l=1.070u w=5.000u
M108 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M109 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M110 NET_106 NET_94 VDD VDD P33 l=0.300u w=5.000u
M111 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M112 NET_94 NET_90 NET_3553 VDD33 P33 l=0.300u w=5.000u
M113 NET_94 NET_90 NET_3553 VDD33 P33 l=0.300u w=5.000u
M114 NET_3553 NET_90 NET_94 VDD33 P33 l=0.300u w=5.000u
M115 NET_94 NET_90 NET_3553 VDD33 P33 l=0.300u w=5.000u
M116 NET_3553 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M117 VDD33 NET_44 NET_3553 VDD33 P33 l=0.300u w=5.000u
M118 NET_3553 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M119 PAD NET_60 NET_5988 NET_1362 P33 l=0.300u w=30.000u
M120 VDD33 NET_3512 NET_5988 NET_1362 P33 l=0.300u w=30.000u
M121 VDD33 NET_3512 NET_5986 NET_1362 P33 l=0.300u w=30.000u
M122 NET_5986 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M123 PAD NET_60 NET_5993 NET_1362 P33 l=0.300u w=30.000u
M124 VDD33 NET_3512 NET_5993 NET_1362 P33 l=0.300u w=30.000u
M125 VDD33 NET_3512 NET_5991 NET_1362 P33 l=0.300u w=30.000u
M126 NET_5991 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M127 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M128 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M129 NET_106 NET_94 VDD VDD P33 l=0.300u w=5.000u
M130 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M131 PAD NET_60 NET_5984 NET_1362 P33 l=0.300u w=30.000u
M132 PAD NET_60 NET_5989 NET_1362 P33 l=0.300u w=30.000u
M133 NET_87 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M134 NET_87 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M135 NET_5978 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M136 NET_5978 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M137 PAD NET_60 NET_5976 NET_1362 P33 l=0.300u w=30.000u
M138 NET_5983 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M139 NET_5983 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M140 PAD NET_60 NET_5981 NET_1362 P33 l=0.300u w=30.000u
M141 NET_5984 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M142 NET_5989 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M143 VDD33 NET_10 NET_87 VDD33 P33 l=0.300u w=5.000u
M144 VDD33 NET_3512 NET_5974 NET_1362 P33 l=0.300u w=30.000u
M145 NET_5974 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M146 VDD33 NET_3512 NET_5979 NET_1362 P33 l=0.300u w=30.000u
M147 NET_5979 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3512 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_10 NET_85 VDD33 P33 l=0.300u w=5.000u
M150 NET_5964 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M151 NET_5964 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M152 NET_5969 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M153 NET_5969 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M154 NET_10 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M157 VDD33 NET_3512 NET_5962 NET_1362 P33 l=0.300u w=30.000u
M158 NET_5962 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M159 PAD NET_60 NET_5960 NET_1362 P33 l=0.300u w=30.000u
M160 VDD33 NET_3512 NET_5967 NET_1362 P33 l=0.300u w=30.000u
M161 NET_5967 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M162 PAD NET_60 NET_5965 NET_1362 P33 l=0.300u w=30.000u
M163 NET_5951 NET_45 VDD33 NET_1362 P33 l=0.300u w=30.000u
M164 NET_5955 NET_45 VDD33 NET_1362 P33 l=0.300u w=30.000u
M165 NET_5960 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M166 NET_5965 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M167 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M171 PAD NET_60 NET_5949 NET_1362 P33 l=0.300u w=30.000u
M172 NET_5949 NET_45 VDD33 NET_1362 P33 l=0.300u w=30.000u
M173 PAD NET_60 NET_5953 NET_1362 P33 l=0.300u w=30.000u
M174 NET_5953 NET_45 VDD33 NET_1362 P33 l=0.300u w=30.000u
M175 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M176 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M177 VDD33 PAD NET_1362 NET_1362 P33 l=0.350u w=5.000u
M178 VDD33 NET_44 NET_3553 VDD33 P33 l=0.300u w=5.000u
M179 NET_5976 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M180 NET_5981 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M181 NET_5951 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M182 NET_5955 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_1362 NET_1362 P33 l=0.350u w=15.000u
M184 PAD VDD33 NET_60 NET_1362 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBU4

.subckt PBU24   PAD OEN I C FP
M1 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M3 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M5 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M8 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M9 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M10 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_51 NET_52 NET_50 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M17 NET_55 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_55 VSS N18 l=0.180u w=2.000u
M19 NET_60 NET_55 VSS VSS N18 l=0.180u w=2.000u
M20 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M21 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M23 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M24 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M25 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M27 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M32 NET_6042 OEN NET_55 VDD P18 l=0.180u w=5.000u
M33 NET_6042 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M35 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M36 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M37 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M38 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M39 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_52 NET_50 VDD P18 l=0.180u w=5.000u
M42 NET_50 NET_52 VDD VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_101 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_101 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_101 NET_25 VSSD N33 l=0.400u w=28.000u
M60 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_101 NET_14 VSSD N33 l=0.400u w=28.000u
M64 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M66 NET_12 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_44 VDD33 NET_104 VSS N33 l=0.350u w=8.000u
M77 NET_44 VDD33 NET_104 VSS N33 l=0.350u w=8.000u
M78 NET_104 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M79 VSS NET_104 NET_108 VSS N33 l=0.350u w=8.000u
M80 VSS NET_108 NET_94 VSS N33 l=0.350u w=2.000u
M81 VSS NET_108 NET_94 VSS N33 l=0.350u w=2.000u
M82 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M83 NET_101 NET_10 VSS VSS N33 l=0.350u w=8.000u
M84 NET_101 NET_10 VSS VSS N33 l=0.350u w=8.000u
M85 VSS NET_10 NET_101 VSS N33 l=0.350u w=8.000u
M86 VSS NET_67 NET_64 VSS N33 l=0.350u w=8.000u
M87 VSS NET_67 NET_64 VSS N33 l=0.350u w=8.000u
M88 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M89 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M90 NET_67 NET_50 VSS VSS N33 l=0.350u w=5.330u
M91 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M92 NET_68 NET_46 VSS VSS N33 l=0.350u w=5.330u
M93 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M94 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M95 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M96 VSS NET_52 NET_76 VSS N33 l=0.350u w=7.440u
M97 NET_76 NET_52 VSS VSS N33 l=0.350u w=7.440u
M98 NET_81 NET_3500 NET_79 VSS N33 l=0.350u w=8.000u
M99 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M100 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M101 VSS NET_55 NET_10 VSS N33 l=0.350u w=8.000u
M102 VSS NET_55 NET_10 VSS N33 l=0.350u w=8.000u
M103 NET_6009 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M104 NET_6009 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M105 NET_6011 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M106 NET_6011 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M107 VDD33 VDD NET_44 NET_1362 P33 l=1.070u w=5.000u
M108 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M109 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M110 NET_94 NET_108 VDD VDD P33 l=0.300u w=5.000u
M111 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M112 PAD NET_79 NET_6002 NET_1362 P33 l=0.300u w=30.000u
M113 VDD33 NET_64 NET_6002 NET_1362 P33 l=0.300u w=30.000u
M114 VDD33 NET_64 NET_6000 NET_1362 P33 l=0.300u w=30.000u
M115 NET_6000 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M116 PAD NET_79 NET_6007 NET_1362 P33 l=0.300u w=30.000u
M117 VDD33 NET_64 NET_6007 NET_1362 P33 l=0.300u w=30.000u
M118 VDD33 NET_64 NET_6005 NET_1362 P33 l=0.300u w=30.000u
M119 NET_6005 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M120 NET_108 NET_104 NET_3541 VDD33 P33 l=0.300u w=5.000u
M121 NET_108 NET_104 NET_3541 VDD33 P33 l=0.300u w=5.000u
M122 NET_3541 NET_104 NET_108 VDD33 P33 l=0.300u w=5.000u
M123 NET_108 NET_104 NET_3541 VDD33 P33 l=0.300u w=5.000u
M124 NET_3541 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 VDD33 NET_44 NET_3541 VDD33 P33 l=0.300u w=5.000u
M126 NET_3541 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M127 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M128 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M129 NET_94 NET_108 VDD VDD P33 l=0.300u w=5.000u
M130 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M131 PAD NET_79 NET_5998 NET_1362 P33 l=0.300u w=30.000u
M132 PAD NET_79 NET_6003 NET_1362 P33 l=0.300u w=30.000u
M133 NET_5998 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M134 NET_5992 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M135 NET_5992 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M136 PAD NET_79 NET_5990 NET_1362 P33 l=0.300u w=30.000u
M137 NET_6003 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M138 NET_5997 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M139 NET_5997 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M140 PAD NET_79 NET_5995 NET_1362 P33 l=0.300u w=30.000u
M141 NET_101 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 NET_101 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M143 VDD33 NET_64 NET_5988 NET_1362 P33 l=0.300u w=30.000u
M144 NET_5988 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M145 VDD33 NET_64 NET_5993 NET_1362 P33 l=0.300u w=30.000u
M146 NET_5993 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M147 VDD33 NET_10 NET_101 VDD33 P33 l=0.300u w=5.000u
M148 NET_5978 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M149 NET_5978 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M150 NET_5983 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M151 NET_5983 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M152 VDD33 VSS NET_3500 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_10 NET_99 VDD33 P33 l=0.300u w=5.000u
M154 NET_10 NET_99 VDD33 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_64 NET_5976 NET_1362 P33 l=0.300u w=30.000u
M156 NET_5976 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M157 PAD NET_79 NET_5974 NET_1362 P33 l=0.300u w=30.000u
M158 VDD33 NET_64 NET_5981 NET_1362 P33 l=0.300u w=30.000u
M159 NET_5981 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M160 PAD NET_79 NET_5979 NET_1362 P33 l=0.300u w=30.000u
M161 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M163 NET_5974 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M164 NET_5965 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M165 NET_5979 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M166 NET_5969 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M167 PAD NET_79 NET_5963 NET_1362 P33 l=0.300u w=30.000u
M168 NET_5963 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M169 PAD NET_79 NET_5967 NET_1362 P33 l=0.300u w=30.000u
M170 NET_5967 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M171 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M172 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M173 VDD33 PAD NET_1362 NET_1362 P33 l=0.350u w=5.000u
M174 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M175 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M177 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M181 VDD33 NET_44 NET_3541 VDD33 P33 l=0.300u w=5.000u
M182 NET_5990 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M183 NET_5995 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M184 NET_5965 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M185 NET_5969 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M186 PAD VDD33 NET_79 NET_1362 P33 l=0.350u w=10.000u
M187 PAD VDD33 NET_1362 NET_1362 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBU24

.subckt PBU2   PAD OEN I C FP
M1 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M3 C NET_102 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M5 C NET_102 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_105 NET_102 VSS N18 l=0.180u w=2.000u
M8 VSS NET_105 NET_102 VSS N18 l=0.180u w=2.000u
M9 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M10 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_71 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_71 NET_72 NET_70 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M17 NET_75 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_75 VSS N18 l=0.180u w=2.000u
M19 VSS NET_75 NET_45 VSS N18 l=0.180u w=2.000u
M20 VSS NET_75 NET_45 VSS N18 l=0.180u w=2.000u
M21 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_105 NET_102 VDD P18 l=0.180u w=5.000u
M23 VDD NET_105 NET_102 VDD P18 l=0.180u w=5.000u
M24 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M25 C NET_102 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M27 C NET_102 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M30 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M33 NET_6016 OEN NET_75 VDD P18 l=0.180u w=5.000u
M34 NET_6016 I VDD VDD P18 l=0.180u w=5.000u
M35 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M36 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M37 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M38 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M39 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_72 NET_70 VDD P18 l=0.180u w=5.000u
M42 NET_70 NET_72 VDD VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M62 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M63 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M64 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M65 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M70 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M72 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M74 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_44 VDD33 NET_89 VSS N33 l=0.350u w=8.000u
M77 NET_44 VDD33 NET_89 VSS N33 l=0.350u w=8.000u
M78 NET_89 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M79 VSS NET_89 NET_93 VSS N33 l=0.350u w=8.000u
M80 VSS NET_93 NET_105 VSS N33 l=0.350u w=2.000u
M81 VSS NET_93 NET_105 VSS N33 l=0.350u w=2.000u
M82 NET_85 NET_45 VSS VSS N33 l=0.350u w=8.000u
M83 VSS NET_46 NET_86 VSS N33 l=0.350u w=4.000u
M84 VSS NET_46 NET_86 VSS N33 l=0.350u w=4.000u
M85 VSS NET_50 NET_47 VSS N33 l=0.350u w=4.000u
M86 VSS NET_50 NET_47 VSS N33 l=0.350u w=4.000u
M87 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M88 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M89 NET_50 NET_70 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M91 NET_51 NET_66 VSS VSS N33 l=0.350u w=5.330u
M92 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M93 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M94 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M95 VSS NET_72 NET_59 VSS N33 l=0.350u w=7.440u
M96 NET_59 NET_72 VSS VSS N33 l=0.350u w=7.440u
M97 NET_64 NET_3507 NET_62 VSS N33 l=0.350u w=8.000u
M98 NET_64 NET_61 VSS VSS N33 l=0.350u w=8.000u
M99 NET_85 NET_45 VSS VSS N33 l=0.350u w=8.000u
M100 NET_46 NET_75 VSS VSS N33 l=0.350u w=8.000u
M101 NET_46 NET_75 VSS VSS N33 l=0.350u w=8.000u
M102 NET_5985 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M103 NET_5985 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M104 NET_5987 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M105 NET_5987 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M106 VDD33 VDD NET_44 NET_1361 P33 l=1.070u w=5.000u
M107 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M108 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M109 NET_105 NET_93 VDD VDD P33 l=0.300u w=5.000u
M110 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M111 NET_93 NET_89 NET_3561 VDD33 P33 l=0.300u w=5.000u
M112 NET_93 NET_89 NET_3561 VDD33 P33 l=0.300u w=5.000u
M113 NET_3561 NET_89 NET_93 VDD33 P33 l=0.300u w=5.000u
M114 NET_93 NET_89 NET_3561 VDD33 P33 l=0.300u w=5.000u
M115 NET_3561 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_44 NET_3561 VDD33 P33 l=0.300u w=5.000u
M117 NET_3561 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M118 PAD NET_62 NET_5978 NET_1361 P33 l=0.300u w=30.000u
M119 VDD33 NET_3507 NET_5978 NET_1361 P33 l=0.300u w=30.000u
M120 VDD33 NET_3507 NET_5976 NET_1361 P33 l=0.300u w=30.000u
M121 NET_5976 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M122 PAD NET_62 NET_5983 NET_1361 P33 l=0.300u w=30.000u
M123 VDD33 NET_3507 NET_5983 NET_1361 P33 l=0.300u w=30.000u
M124 VDD33 NET_3507 NET_5981 NET_1361 P33 l=0.300u w=30.000u
M125 NET_5981 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M126 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M127 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M128 NET_105 NET_93 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M130 PAD NET_62 NET_5974 NET_1361 P33 l=0.300u w=30.000u
M131 PAD NET_62 NET_5979 NET_1361 P33 l=0.300u w=30.000u
M132 VDD33 NET_46 NET_86 VDD33 P33 l=0.300u w=5.000u
M133 NET_5968 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M134 NET_5968 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M135 PAD NET_62 NET_5966 NET_1361 P33 l=0.300u w=30.000u
M136 NET_5973 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M137 NET_5973 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M138 PAD NET_62 NET_5971 NET_1361 P33 l=0.300u w=30.000u
M139 NET_5974 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M140 NET_5979 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M141 VDD33 NET_3507 NET_5964 NET_1361 P33 l=0.300u w=30.000u
M142 NET_5964 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M143 VDD33 NET_3507 NET_5969 NET_1361 P33 l=0.300u w=30.000u
M144 NET_5969 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M145 VDD33 VSS NET_3507 VDD33 P33 l=0.300u w=5.000u
M146 VDD33 NET_46 NET_85 VDD33 P33 l=0.300u w=5.000u
M147 NET_5954 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M148 NET_5954 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M149 NET_5959 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M150 NET_5959 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M151 NET_46 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_61 NET_59 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_59 NET_61 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_3507 NET_5952 NET_1361 P33 l=0.300u w=30.000u
M155 NET_5952 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M156 PAD NET_62 NET_5950 NET_1361 P33 l=0.300u w=30.000u
M157 VDD33 NET_3507 NET_5957 NET_1361 P33 l=0.300u w=30.000u
M158 NET_5957 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M159 PAD NET_62 NET_5955 NET_1361 P33 l=0.300u w=30.000u
M160 NET_5941 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M161 NET_5945 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M162 NET_5950 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M163 NET_5955 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M164 VDD33 NET_50 NET_51 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M166 NET_47 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M167 NET_47 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_50 NET_47 VDD33 P33 l=0.300u w=5.000u
M169 PAD NET_62 NET_5939 NET_1361 P33 l=0.300u w=30.000u
M170 NET_5939 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M171 PAD NET_62 NET_5943 NET_1361 P33 l=0.300u w=30.000u
M172 NET_5943 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M173 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M174 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M175 VDD33 PAD NET_1361 NET_1361 P33 l=0.350u w=5.000u
M176 VDD33 NET_44 NET_3561 VDD33 P33 l=0.300u w=5.000u
M177 NET_5966 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M178 NET_5971 NET_3507 VDD33 NET_1361 P33 l=0.300u w=30.000u
M179 NET_5941 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M180 NET_5945 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_1361 NET_1361 P33 l=0.350u w=15.000u
M182 PAD VDD33 NET_62 NET_1361 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBU2

.subckt PBU16   PAD OEN I C FP
M1 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M3 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M5 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M8 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M9 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M10 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_51 NET_52 NET_50 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M17 NET_55 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_55 VSS N18 l=0.180u w=2.000u
M19 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M20 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M21 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M23 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M24 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M25 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M27 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M32 NET_6041 OEN NET_55 VDD P18 l=0.180u w=5.000u
M33 NET_6041 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M35 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M36 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M37 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M38 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_52 NET_50 VDD P18 l=0.180u w=5.000u
M41 NET_50 NET_52 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_100 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_100 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M62 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M63 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M64 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M65 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M70 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M72 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M74 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M77 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M78 NET_103 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M79 VSS NET_103 NET_107 VSS N33 l=0.350u w=8.000u
M80 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M81 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M82 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M83 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M84 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M85 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M86 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M87 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M88 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M89 NET_67 NET_50 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M91 NET_68 NET_46 VSS VSS N33 l=0.350u w=5.330u
M92 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M93 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M94 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M95 VSS NET_52 NET_76 VSS N33 l=0.350u w=7.440u
M96 NET_76 NET_52 VSS VSS N33 l=0.350u w=7.440u
M97 NET_81 NET_3502 NET_79 VSS N33 l=0.350u w=8.000u
M98 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M99 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M100 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M101 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M102 NET_6010 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M103 NET_6010 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M104 NET_6012 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M105 NET_6012 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M106 VDD33 VDD NET_44 NET_1361 P33 l=1.070u w=5.000u
M107 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M108 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M109 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M110 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M111 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M112 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M113 NET_3544 NET_103 NET_107 VDD33 P33 l=0.300u w=5.000u
M114 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M115 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M117 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M118 PAD NET_79 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M119 VDD33 NET_3502 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M120 VDD33 NET_3502 NET_6001 NET_1361 P33 l=0.300u w=30.000u
M121 NET_6001 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M122 PAD NET_79 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M123 VDD33 NET_3502 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M124 VDD33 NET_3502 NET_6006 NET_1361 P33 l=0.300u w=30.000u
M125 NET_6006 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M126 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M127 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M128 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M130 PAD NET_79 NET_5999 NET_1361 P33 l=0.300u w=30.000u
M131 PAD NET_79 NET_6004 NET_1361 P33 l=0.300u w=30.000u
M132 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M133 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M134 NET_5993 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M135 NET_5993 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M136 PAD NET_79 NET_5991 NET_1361 P33 l=0.300u w=30.000u
M137 NET_5998 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M138 NET_5998 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M139 PAD NET_79 NET_5996 NET_1361 P33 l=0.300u w=30.000u
M140 NET_5999 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M141 NET_6004 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M142 VDD33 NET_82 NET_100 VDD33 P33 l=0.300u w=5.000u
M143 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M144 VDD33 NET_64 NET_5989 NET_1361 P33 l=0.300u w=30.000u
M145 NET_5989 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M146 VDD33 NET_64 NET_5994 NET_1361 P33 l=0.300u w=30.000u
M147 NET_5994 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3502 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_82 NET_99 VDD33 P33 l=0.300u w=5.000u
M150 NET_5979 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M151 NET_5979 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M152 NET_5984 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M153 NET_5984 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M154 NET_82 NET_99 VDD33 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M157 VDD33 NET_64 NET_5977 NET_1361 P33 l=0.300u w=30.000u
M158 NET_5977 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M159 PAD NET_79 NET_5975 NET_1361 P33 l=0.300u w=30.000u
M160 VDD33 NET_64 NET_5982 NET_1361 P33 l=0.300u w=30.000u
M161 NET_5982 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M162 PAD NET_79 NET_5980 NET_1361 P33 l=0.300u w=30.000u
M163 NET_5966 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M164 NET_5970 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M165 NET_5975 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M166 NET_5980 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M167 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M168 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M172 PAD NET_79 NET_5964 NET_1361 P33 l=0.300u w=30.000u
M173 NET_5964 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M174 PAD NET_79 NET_5968 NET_1361 P33 l=0.300u w=30.000u
M175 NET_5968 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M176 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M177 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M178 VDD33 PAD NET_1361 NET_1361 P33 l=0.350u w=5.000u
M179 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M180 NET_5991 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M181 NET_5996 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M182 NET_5966 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M183 NET_5970 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_79 NET_1361 P33 l=0.350u w=10.000u
M185 PAD VDD33 NET_1361 NET_1361 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBU16

.subckt PBU12   PAD OEN I C FP
M1 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M3 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M5 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M8 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M9 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M10 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_51 NET_52 NET_50 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M17 NET_55 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_55 VSS N18 l=0.180u w=2.000u
M19 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M20 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M21 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M23 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M24 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M25 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M27 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M32 NET_6041 OEN NET_55 VDD P18 l=0.180u w=5.000u
M33 NET_6041 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M35 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M36 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M37 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M38 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_52 NET_50 VDD P18 l=0.180u w=5.000u
M41 NET_50 NET_52 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_100 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_100 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M62 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M63 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M64 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M65 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M70 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M72 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M74 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M77 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M78 NET_103 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M79 VSS NET_103 NET_107 VSS N33 l=0.350u w=8.000u
M80 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M81 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M82 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M83 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M84 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M85 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M86 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M87 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M88 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M89 NET_67 NET_50 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M91 NET_68 NET_46 VSS VSS N33 l=0.350u w=5.330u
M92 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M93 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M94 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M95 VSS NET_52 NET_76 VSS N33 l=0.350u w=7.440u
M96 NET_76 NET_52 VSS VSS N33 l=0.350u w=7.440u
M97 NET_81 NET_3502 NET_79 VSS N33 l=0.350u w=8.000u
M98 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M99 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M100 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M101 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M102 NET_6010 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M103 NET_6010 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M104 NET_6012 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M105 NET_6012 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M106 VDD33 VDD NET_44 NET_1361 P33 l=1.070u w=5.000u
M107 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M108 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M109 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M110 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M111 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M112 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M113 NET_3544 NET_103 NET_107 VDD33 P33 l=0.300u w=5.000u
M114 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M115 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M117 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M118 PAD NET_79 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M119 VDD33 NET_3502 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M120 VDD33 NET_3502 NET_6001 NET_1361 P33 l=0.300u w=30.000u
M121 NET_6001 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M122 PAD NET_79 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M123 VDD33 NET_3502 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M124 VDD33 NET_3502 NET_6006 NET_1361 P33 l=0.300u w=30.000u
M125 NET_6006 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M126 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M127 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M128 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M130 PAD NET_79 NET_5999 NET_1361 P33 l=0.300u w=30.000u
M131 PAD NET_79 NET_6004 NET_1361 P33 l=0.300u w=30.000u
M132 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M133 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M134 NET_5993 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M135 NET_5993 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M136 PAD NET_79 NET_5991 NET_1361 P33 l=0.300u w=30.000u
M137 NET_5998 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M138 NET_5998 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M139 PAD NET_79 NET_5996 NET_1361 P33 l=0.300u w=30.000u
M140 NET_5999 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M141 NET_6004 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M142 VDD33 NET_82 NET_100 VDD33 P33 l=0.300u w=5.000u
M143 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M144 VDD33 NET_64 NET_5989 NET_1361 P33 l=0.300u w=30.000u
M145 NET_5989 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M146 VDD33 NET_64 NET_5994 NET_1361 P33 l=0.300u w=30.000u
M147 NET_5994 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3502 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_82 NET_99 VDD33 P33 l=0.300u w=5.000u
M150 NET_5979 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M151 NET_5979 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M152 NET_5984 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M153 NET_5984 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M154 NET_82 NET_99 VDD33 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M157 VDD33 NET_64 NET_5977 NET_1361 P33 l=0.300u w=30.000u
M158 NET_5977 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M159 PAD NET_79 NET_5975 NET_1361 P33 l=0.300u w=30.000u
M160 VDD33 NET_64 NET_5982 NET_1361 P33 l=0.300u w=30.000u
M161 NET_5982 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M162 PAD NET_79 NET_5980 NET_1361 P33 l=0.300u w=30.000u
M163 NET_5966 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M164 NET_5970 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M165 NET_5975 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M166 NET_5980 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M167 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M168 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M172 PAD NET_79 NET_5964 NET_1361 P33 l=0.300u w=30.000u
M173 NET_5964 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M174 PAD NET_79 NET_5968 NET_1361 P33 l=0.300u w=30.000u
M175 NET_5968 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M176 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M177 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M178 VDD33 PAD NET_1361 NET_1361 P33 l=0.350u w=5.000u
M179 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M180 NET_5991 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M181 NET_5996 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M182 NET_5966 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M183 NET_5970 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_79 NET_1361 P33 l=0.350u w=10.000u
M185 PAD VDD33 NET_1361 NET_1361 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBU12

.subckt PBSUL8   PAD OEN I C FP
M1 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M3 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M5 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M8 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M9 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M10 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_71 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_71 NET_72 NET_70 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M17 NET_75 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_75 VSS N18 l=0.180u w=2.000u
M19 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M25 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M27 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M29 NET_5936 OEN NET_75 VDD P18 l=0.180u w=5.000u
M30 NET_5936 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M32 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M33 NET_46 NET_75 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M35 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M39 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M40 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M41 VDD NET_72 NET_70 VDD P18 l=0.180u w=5.000u
M42 NET_70 NET_72 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_25 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M77 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M78 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M79 NET_49 NET_50 VSS VSS N33 l=0.350u w=4.600u
M80 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M81 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M82 NET_50 NET_70 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M84 NET_51 NET_66 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M86 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_72 NET_59 VSS N33 l=0.350u w=7.440u
M89 NET_59 NET_72 VSS VSS N33 l=0.350u w=7.440u
M90 NET_64 NET_3500 NET_62 VSS N33 l=0.350u w=8.000u
M91 NET_64 NET_61 VSS VSS N33 l=0.350u w=8.000u
M92 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M93 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M94 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M95 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M97 NET_90 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M98 NET_84 NET_90 NET_94 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_90 VSS VSS N33 l=0.350u w=8.000u
M100 NET_84 NET_94 VDD33 VSS N33 l=0.350u w=0.820u
M101 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M102 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M103 VSS NET_94 NET_3549 VDD33 P33 l=0.300u w=5.100u
M104 VSS NET_94 NET_3549 VDD33 P33 l=0.300u w=5.100u
M105 NET_5917 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M106 NET_5917 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M107 NET_5919 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M108 NET_5919 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M109 VDD33 VDD NET_45 NET_1363 P33 l=1.070u w=5.000u
M110 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M111 NET_3549 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M112 NET_94 NET_90 NET_3549 VDD33 P33 l=0.300u w=5.000u
M113 NET_94 NET_90 NET_3549 VDD33 P33 l=0.300u w=5.000u
M114 NET_3549 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M115 PAD NET_62 NET_5910 NET_1363 P33 l=0.300u w=30.000u
M116 NET_5910 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M117 VDD33 NET_3500 NET_5908 NET_1363 P33 l=0.300u w=30.000u
M118 NET_5908 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M119 PAD NET_62 NET_5915 NET_1363 P33 l=0.300u w=30.000u
M120 NET_5915 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M121 VDD33 NET_3500 NET_5913 NET_1363 P33 l=0.300u w=30.000u
M122 NET_5913 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M123 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M124 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M125 NET_107 NET_94 VDD VDD P33 l=0.300u w=5.000u
M126 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M127 NET_85 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M128 PAD NET_62 NET_5906 NET_1363 P33 l=0.300u w=30.000u
M129 NET_5906 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M130 NET_5904 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M131 NET_5904 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M132 PAD NET_62 NET_5896 NET_1363 P33 l=0.300u w=30.000u
M133 PAD NET_62 NET_5911 NET_1363 P33 l=0.300u w=30.000u
M134 NET_5911 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M135 NET_5905 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M136 NET_5905 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M137 PAD NET_62 NET_5900 NET_1363 P33 l=0.300u w=30.000u
M138 VDD33 VSS NET_3500 VDD33 P33 l=0.300u w=5.000u
M139 NET_47 NET_89 VDD33 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_47 NET_89 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_3500 NET_5894 NET_1363 P33 l=0.300u w=30.000u
M142 NET_5894 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M143 NET_5886 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M144 NET_5886 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M145 VDD33 NET_3500 NET_5898 NET_1363 P33 l=0.300u w=30.000u
M146 NET_5898 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M147 NET_5891 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M148 NET_5891 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M149 VDD33 NET_61 NET_59 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_59 NET_61 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_49 NET_5884 NET_1363 P33 l=0.300u w=30.000u
M152 NET_5884 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M153 PAD NET_62 NET_5882 NET_1363 P33 l=0.300u w=30.000u
M154 NET_5882 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M155 NET_5873 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M156 VDD33 NET_49 NET_5889 NET_1363 P33 l=0.300u w=30.000u
M157 NET_5889 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M158 PAD NET_62 NET_5887 NET_1363 P33 l=0.300u w=30.000u
M159 NET_5887 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M160 NET_5877 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M161 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M163 NET_49 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_50 NET_51 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M167 PAD NET_62 NET_5871 NET_1363 P33 l=0.300u w=30.000u
M168 NET_5871 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M169 PAD NET_62 NET_5875 NET_1363 P33 l=0.300u w=30.000u
M170 NET_5875 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M171 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M172 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M173 VDD33 PAD NET_1363 NET_1363 P33 l=0.350u w=5.000u
M174 NET_3549 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M175 VDD33 NET_45 NET_3549 VDD33 P33 l=0.300u w=5.000u
M176 PAD VDD33 NET_1363 NET_1363 P33 l=0.350u w=15.000u
M177 NET_5896 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M178 NET_5873 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M179 NET_5900 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M180 NET_5877 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_62 NET_1363 P33 l=0.350u w=10.000u
R1 PAD NET_45 300.135
.ends PBSUL8

.subckt PBSUL24   PAD OEN I C FP
M1 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M3 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M5 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M8 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M9 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M10 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_71 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_71 NET_72 NET_70 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M17 NET_75 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_75 VSS N18 l=0.180u w=2.000u
M19 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M25 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M27 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M29 NET_5934 OEN NET_75 VDD P18 l=0.180u w=5.000u
M30 NET_5934 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M32 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M33 NET_46 NET_75 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M35 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M39 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M40 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M41 VDD NET_72 NET_70 VDD P18 l=0.180u w=5.000u
M42 NET_70 NET_72 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_85 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_85 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_85 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_85 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M77 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M78 NET_90 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M79 NET_84 NET_90 NET_94 VSS N33 l=0.350u w=8.000u
M80 NET_84 NET_90 VSS VSS N33 l=0.350u w=8.000u
M81 NET_84 NET_94 VDD33 VSS N33 l=0.350u w=0.820u
M82 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M83 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M84 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M85 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M86 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M87 NET_49 NET_50 VSS VSS N33 l=0.350u w=4.400u
M88 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M89 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M90 NET_50 NET_70 VSS VSS N33 l=0.350u w=5.330u
M91 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M92 NET_51 NET_66 VSS VSS N33 l=0.350u w=5.330u
M93 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M94 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M95 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M96 VSS NET_72 NET_59 VSS N33 l=0.350u w=7.440u
M97 NET_59 NET_72 VSS VSS N33 l=0.350u w=7.440u
M98 NET_64 NET_3500 NET_62 VSS N33 l=0.350u w=8.000u
M99 NET_64 NET_61 VSS VSS N33 l=0.350u w=8.000u
M100 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M101 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M102 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M103 NET_5915 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M104 NET_5915 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M105 NET_5917 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M106 NET_5917 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M107 VDD33 VDD NET_45 NET_1363 P33 l=1.070u w=5.000u
M108 VSS NET_94 NET_3547 VDD33 P33 l=0.300u w=5.100u
M109 VSS NET_94 NET_3547 VDD33 P33 l=0.300u w=5.100u
M110 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M111 PAD NET_62 NET_5908 NET_1363 P33 l=0.300u w=30.000u
M112 NET_5908 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M113 VDD33 NET_49 NET_5906 NET_1363 P33 l=0.300u w=30.000u
M114 NET_5906 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M115 PAD NET_62 NET_5913 NET_1363 P33 l=0.300u w=30.000u
M116 NET_5913 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M117 VDD33 NET_49 NET_5911 NET_1363 P33 l=0.300u w=30.000u
M118 NET_5911 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M119 NET_3547 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M120 NET_94 NET_90 NET_3547 VDD33 P33 l=0.300u w=5.000u
M121 NET_94 NET_90 NET_3547 VDD33 P33 l=0.300u w=5.000u
M122 NET_3547 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M124 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M125 NET_107 NET_94 VDD VDD P33 l=0.300u w=5.000u
M126 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M127 PAD NET_62 NET_5904 NET_1363 P33 l=0.300u w=30.000u
M128 NET_5904 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M129 NET_5902 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M130 NET_5902 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M131 PAD NET_62 NET_5894 NET_1363 P33 l=0.300u w=30.000u
M132 PAD NET_62 NET_5909 NET_1363 P33 l=0.300u w=30.000u
M133 NET_5909 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M134 NET_5903 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M135 NET_5903 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M136 PAD NET_62 NET_5898 NET_1363 P33 l=0.300u w=30.000u
M137 VDD33 NET_47 NET_85 VDD33 P33 l=0.300u w=4.600u
M138 VDD33 NET_49 NET_5892 NET_1363 P33 l=0.300u w=30.000u
M139 NET_5892 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M140 NET_5884 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M141 NET_5884 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M142 VDD33 NET_49 NET_5896 NET_1363 P33 l=0.300u w=30.000u
M143 NET_5896 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M144 NET_5889 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M145 NET_5889 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M146 VDD33 VSS NET_3500 VDD33 P33 l=0.300u w=5.000u
M147 NET_47 NET_89 VDD33 VDD33 P33 l=0.300u w=5.000u
M148 VDD33 NET_47 NET_89 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_49 NET_5882 NET_1363 P33 l=0.300u w=30.000u
M150 NET_5882 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M151 PAD NET_62 NET_5880 NET_1363 P33 l=0.300u w=30.000u
M152 NET_5880 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M153 NET_5871 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M154 VDD33 NET_49 NET_5887 NET_1363 P33 l=0.300u w=30.000u
M155 NET_5887 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M156 PAD NET_62 NET_5885 NET_1363 P33 l=0.300u w=30.000u
M157 NET_5885 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M158 NET_5875 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M159 VDD33 NET_61 NET_59 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_59 NET_61 VDD33 P33 l=0.300u w=5.000u
M161 PAD NET_62 NET_5869 NET_1363 P33 l=0.300u w=30.000u
M162 NET_5869 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M163 PAD NET_62 NET_5873 NET_1363 P33 l=0.300u w=30.000u
M164 NET_5873 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M165 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M166 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M167 VDD33 PAD NET_1363 NET_1363 P33 l=0.350u w=5.000u
M168 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M170 NET_49 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_50 NET_51 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M174 PAD VDD33 NET_1363 NET_1363 P33 l=0.350u w=15.000u
M175 NET_5894 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M176 NET_5871 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M177 NET_5898 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M178 NET_5875 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M179 PAD VDD33 NET_62 NET_1363 P33 l=0.350u w=10.000u
M180 NET_3547 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M181 VDD33 NET_45 NET_3547 VDD33 P33 l=0.300u w=5.000u
R1 PAD NET_45 300.135
.ends PBSUL24

.subckt PBSUL16   PAD OEN I C FP
M1 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M3 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M5 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M8 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M9 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M10 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_71 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_71 NET_72 NET_70 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M17 NET_75 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_75 VSS N18 l=0.180u w=2.000u
M19 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M25 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M27 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M29 NET_5926 OEN NET_75 VDD P18 l=0.180u w=5.000u
M30 NET_5926 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M32 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M33 NET_46 NET_75 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M35 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M39 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M40 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M41 VDD NET_72 NET_70 VDD P18 l=0.180u w=5.000u
M42 NET_70 NET_72 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_85 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_85 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M77 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M78 NET_90 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M79 NET_84 NET_90 NET_94 VSS N33 l=0.350u w=8.000u
M80 NET_84 NET_90 VSS VSS N33 l=0.350u w=8.000u
M81 NET_84 NET_94 VDD33 VSS N33 l=0.350u w=0.820u
M82 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M83 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M84 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M85 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M86 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M87 NET_49 NET_50 VSS VSS N33 l=0.350u w=3.400u
M88 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M89 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M90 NET_50 NET_70 VSS VSS N33 l=0.350u w=5.330u
M91 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M92 NET_51 NET_66 VSS VSS N33 l=0.350u w=5.330u
M93 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M94 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M95 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M96 VSS NET_72 NET_59 VSS N33 l=0.350u w=7.440u
M97 NET_59 NET_72 VSS VSS N33 l=0.350u w=7.440u
M98 NET_64 NET_3500 NET_62 VSS N33 l=0.350u w=8.000u
M99 NET_64 NET_61 VSS VSS N33 l=0.350u w=8.000u
M100 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M101 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M102 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M103 VSS NET_94 NET_3547 VDD33 P33 l=0.300u w=5.100u
M104 VSS NET_94 NET_3547 VDD33 P33 l=0.300u w=5.100u
M105 NET_5907 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M106 NET_5907 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M107 NET_5909 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M108 NET_5909 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M109 VDD33 VDD NET_45 NET_1363 P33 l=1.070u w=5.000u
M110 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M111 NET_94 NET_90 NET_3547 VDD33 P33 l=0.300u w=5.000u
M112 NET_94 NET_90 NET_3547 VDD33 P33 l=0.300u w=5.000u
M113 NET_3547 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M114 NET_3547 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M115 PAD NET_62 NET_5900 NET_1363 P33 l=0.300u w=30.000u
M116 NET_5900 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M117 VDD33 NET_3500 NET_5898 NET_1363 P33 l=0.300u w=30.000u
M118 NET_5898 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M119 PAD NET_62 NET_5905 NET_1363 P33 l=0.300u w=30.000u
M120 NET_5905 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M121 VDD33 NET_3500 NET_5903 NET_1363 P33 l=0.300u w=30.000u
M122 NET_5903 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M123 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M124 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M125 NET_107 NET_94 VDD VDD P33 l=0.300u w=5.000u
M126 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M127 NET_85 NET_47 VDD33 VDD33 P33 l=0.300u w=3.600u
M128 PAD NET_62 NET_5896 NET_1363 P33 l=0.300u w=30.000u
M129 NET_5896 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M130 NET_5894 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M131 NET_5894 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M132 PAD NET_62 NET_5886 NET_1363 P33 l=0.300u w=30.000u
M133 PAD NET_62 NET_5901 NET_1363 P33 l=0.300u w=30.000u
M134 NET_5901 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M135 NET_5895 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M136 NET_5895 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M137 PAD NET_62 NET_5890 NET_1363 P33 l=0.300u w=30.000u
M138 VDD33 VSS NET_3500 VDD33 P33 l=0.300u w=5.000u
M139 NET_47 NET_89 VDD33 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_47 NET_89 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_49 NET_5884 NET_1363 P33 l=0.300u w=30.000u
M142 NET_5884 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M143 NET_5876 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M144 NET_5876 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M145 VDD33 NET_49 NET_5888 NET_1363 P33 l=0.300u w=30.000u
M146 NET_5888 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M147 NET_5881 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M148 NET_5881 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M149 VDD33 NET_61 NET_59 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_59 NET_61 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_49 NET_5874 NET_1363 P33 l=0.300u w=30.000u
M152 NET_5874 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M153 PAD NET_62 NET_5872 NET_1363 P33 l=0.300u w=30.000u
M154 NET_5872 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M155 NET_5863 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M156 VDD33 NET_49 NET_5879 NET_1363 P33 l=0.300u w=30.000u
M157 NET_5879 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M158 PAD NET_62 NET_5877 NET_1363 P33 l=0.300u w=30.000u
M159 NET_5877 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M160 NET_5867 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M161 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M163 NET_49 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_50 NET_51 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M167 PAD NET_62 NET_5861 NET_1363 P33 l=0.300u w=30.000u
M168 NET_5861 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M169 PAD NET_62 NET_5865 NET_1363 P33 l=0.300u w=30.000u
M170 NET_5865 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M171 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M172 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M173 VDD33 PAD NET_1363 NET_1363 P33 l=0.350u w=5.000u
M174 VDD33 NET_45 NET_3547 VDD33 P33 l=0.300u w=5.000u
M175 NET_3547 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M176 PAD VDD33 NET_1363 NET_1363 P33 l=0.350u w=15.000u
M177 NET_5886 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M178 NET_5863 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M179 NET_5890 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M180 NET_5867 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_62 NET_1363 P33 l=0.350u w=10.000u
R1 PAD NET_45 300.135
.ends PBSUL16

.subckt PBSUL12   PAD OEN I C FP
M1 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M3 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M5 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M8 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M9 VSS NET_71 NET_67 VSS N18 l=0.180u w=4.000u
M10 VSS NET_71 NET_67 VSS N18 l=0.180u w=4.000u
M11 NET_72 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_72 NET_73 NET_71 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M17 NET_76 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_76 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_76 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M23 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M24 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M25 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M27 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M30 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_73 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_73 VDD P18 l=0.180u w=5.000u
M33 NET_5959 OEN NET_76 VDD P18 l=0.180u w=5.000u
M34 NET_5959 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_46 NET_76 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M37 VDD NET_71 NET_67 VDD P18 l=0.180u w=5.000u
M38 VDD NET_71 NET_67 VDD P18 l=0.180u w=5.000u
M39 NET_71 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_71 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_73 NET_71 VDD P18 l=0.180u w=5.000u
M42 NET_71 NET_73 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_86 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_86 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_45 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M77 NET_45 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M78 NET_91 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M79 NET_85 NET_91 NET_95 VSS N33 l=0.350u w=8.000u
M80 NET_85 NET_91 VSS VSS N33 l=0.350u w=8.000u
M81 NET_85 NET_95 VDD33 VSS N33 l=0.350u w=0.820u
M82 VSS NET_95 NET_108 VSS N33 l=0.350u w=2.000u
M83 VSS NET_95 NET_108 VSS N33 l=0.350u w=2.000u
M84 VSS NET_47 NET_86 VSS N33 l=0.350u w=8.000u
M85 VSS NET_47 NET_86 VSS N33 l=0.350u w=8.000u
M86 VSS NET_51 NET_48 VSS N33 l=0.350u w=5.000u
M87 VSS NET_51 NET_48 VSS N33 l=0.350u w=5.000u
M88 VSS NET_71 NET_51 VSS N33 l=0.350u w=5.330u
M89 VSS NET_71 NET_51 VSS N33 l=0.350u w=5.330u
M90 NET_51 NET_71 VSS VSS N33 l=0.350u w=5.330u
M91 VSS NET_67 NET_52 VSS N33 l=0.350u w=5.330u
M92 NET_52 NET_67 VSS VSS N33 l=0.350u w=5.330u
M93 VSS NET_67 NET_52 VSS N33 l=0.350u w=5.330u
M94 NET_62 OEN VSS VSS N33 l=0.350u w=7.440u
M95 NET_62 OEN VSS VSS N33 l=0.350u w=7.440u
M96 VSS NET_73 NET_60 VSS N33 l=0.350u w=7.440u
M97 NET_60 NET_73 VSS VSS N33 l=0.350u w=7.440u
M98 NET_65 NET_3501 NET_63 VSS N33 l=0.350u w=8.000u
M99 NET_65 NET_62 VSS VSS N33 l=0.350u w=8.000u
M100 NET_90 NET_46 VSS VSS N33 l=0.350u w=8.000u
M101 VSS NET_76 NET_47 VSS N33 l=0.350u w=8.000u
M102 VSS NET_76 NET_47 VSS N33 l=0.350u w=8.000u
M103 NET_90 NET_46 VSS VSS N33 l=0.350u w=8.000u
M104 VSS NET_95 NET_3551 VDD33 P33 l=0.300u w=5.100u
M105 VSS NET_95 NET_3551 VDD33 P33 l=0.300u w=5.100u
M106 NET_5940 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M107 NET_5940 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M108 NET_5942 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M109 NET_5942 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M110 VDD33 VDD NET_45 NET_1364 P33 l=1.070u w=5.000u
M111 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M112 NET_3551 NET_95 VSS VDD33 P33 l=0.300u w=5.100u
M113 NET_95 NET_91 NET_3551 VDD33 P33 l=0.300u w=5.000u
M114 NET_95 NET_91 NET_3551 VDD33 P33 l=0.300u w=5.000u
M115 NET_3551 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M116 PAD NET_63 NET_5933 NET_1364 P33 l=0.300u w=30.000u
M117 NET_5933 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_3501 NET_5931 NET_1364 P33 l=0.300u w=30.000u
M119 NET_5931 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M120 PAD NET_63 NET_5938 NET_1364 P33 l=0.300u w=30.000u
M121 NET_5938 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M122 VDD33 NET_3501 NET_5936 NET_1364 P33 l=0.300u w=30.000u
M123 NET_5936 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M124 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M125 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M126 NET_108 NET_95 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M128 PAD NET_63 NET_5929 NET_1364 P33 l=0.300u w=30.000u
M129 PAD NET_63 NET_5934 NET_1364 P33 l=0.300u w=30.000u
M130 VDD33 NET_47 NET_86 VDD33 P33 l=0.300u w=4.800u
M131 VDD33 NET_47 NET_86 VDD33 P33 l=0.300u w=4.800u
M132 NET_5927 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M133 NET_5927 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M134 PAD NET_63 NET_5919 NET_1364 P33 l=0.300u w=30.000u
M135 NET_5928 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M136 NET_5928 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M137 PAD NET_63 NET_5923 NET_1364 P33 l=0.300u w=30.000u
M138 NET_5929 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M139 NET_5934 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M140 VDD33 NET_48 NET_5917 NET_1364 P33 l=0.300u w=30.000u
M141 NET_5917 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M142 VDD33 NET_48 NET_5921 NET_1364 P33 l=0.300u w=30.000u
M143 NET_5921 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M144 VDD33 VSS NET_3501 VDD33 P33 l=0.300u w=5.000u
M145 VDD33 NET_47 NET_90 VDD33 P33 l=0.300u w=5.000u
M146 NET_5909 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M147 NET_5909 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M148 NET_5914 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M149 NET_5914 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M150 NET_47 NET_90 VDD33 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_62 NET_60 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_60 NET_62 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_48 NET_5907 NET_1364 P33 l=0.300u w=30.000u
M154 NET_5907 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M155 PAD NET_63 NET_5905 NET_1364 P33 l=0.300u w=30.000u
M156 VDD33 NET_48 NET_5912 NET_1364 P33 l=0.300u w=30.000u
M157 NET_5912 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M158 PAD NET_63 NET_5910 NET_1364 P33 l=0.300u w=30.000u
M159 NET_5896 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M160 NET_5900 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M161 NET_5905 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M162 NET_5910 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M163 VDD33 NET_51 NET_48 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_51 NET_48 VDD33 P33 l=0.300u w=5.000u
M165 NET_48 NET_51 VDD33 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_51 NET_48 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_51 NET_52 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_52 NET_51 VDD33 P33 l=0.300u w=5.000u
M169 PAD NET_63 NET_5894 NET_1364 P33 l=0.300u w=30.000u
M170 NET_5894 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M171 PAD NET_63 NET_5898 NET_1364 P33 l=0.300u w=30.000u
M172 NET_5898 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M173 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M174 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M175 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M176 NET_3551 NET_95 VSS VDD33 P33 l=0.300u w=5.100u
M177 VDD33 NET_45 NET_3551 VDD33 P33 l=0.300u w=5.000u
M178 NET_5919 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M179 NET_5923 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M180 NET_5896 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M181 NET_5900 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M182 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
M183 PAD VDD33 NET_63 NET_1364 P33 l=0.350u w=10.000u
R1 PAD NET_45 300.135
.ends PBSUL12

.subckt PBSU8   PAD OEN I C FP
M1 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M3 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M5 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M8 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M9 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M10 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M11 NET_52 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_52 NET_53 NET_51 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M17 NET_56 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_56 VSS N18 l=0.180u w=2.000u
M19 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M20 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M21 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M23 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M24 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M25 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M27 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M30 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M33 NET_5983 OEN NET_56 VDD P18 l=0.180u w=5.000u
M34 NET_5983 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_61 NET_56 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M37 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M38 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M39 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_53 NET_51 VDD P18 l=0.180u w=5.000u
M42 NET_51 NET_53 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_25 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M77 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M78 NET_105 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M79 NET_85 NET_105 NET_109 VSS N33 l=0.350u w=8.000u
M80 NET_85 NET_105 VSS VSS N33 l=0.350u w=8.000u
M81 NET_85 NET_109 VDD33 VSS N33 l=0.350u w=0.820u
M82 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M83 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M84 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M85 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M86 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M87 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M88 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M89 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M90 NET_68 NET_51 VSS VSS N33 l=0.350u w=5.330u
M91 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M92 NET_69 NET_47 VSS VSS N33 l=0.350u w=5.330u
M93 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M94 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M95 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M96 VSS NET_53 NET_77 VSS N33 l=0.350u w=7.440u
M97 NET_77 NET_53 VSS VSS N33 l=0.350u w=7.440u
M98 NET_82 NET_3505 NET_80 VSS N33 l=0.350u w=8.000u
M99 NET_82 NET_79 VSS VSS N33 l=0.350u w=8.000u
M100 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M101 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M102 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M103 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M104 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M105 NET_5964 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M106 NET_5964 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M107 NET_5966 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M108 NET_5966 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M109 VDD33 VDD NET_45 NET_1364 P33 l=1.070u w=5.000u
M110 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M111 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M112 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M113 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M114 NET_3547 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M115 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M116 PAD NET_80 NET_5957 NET_1364 P33 l=0.300u w=30.000u
M117 NET_5957 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_3505 NET_5955 NET_1364 P33 l=0.300u w=30.000u
M119 NET_5955 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M120 PAD NET_80 NET_5962 NET_1364 P33 l=0.300u w=30.000u
M121 NET_5962 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M122 VDD33 NET_3505 NET_5960 NET_1364 P33 l=0.300u w=30.000u
M123 NET_5960 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M124 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M125 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M126 NET_96 NET_109 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M128 PAD NET_80 NET_5953 NET_1364 P33 l=0.300u w=30.000u
M129 PAD NET_80 NET_5958 NET_1364 P33 l=0.300u w=30.000u
M130 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M131 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M132 NET_5951 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M133 NET_5951 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M134 PAD NET_80 NET_5943 NET_1364 P33 l=0.300u w=30.000u
M135 NET_5952 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M136 NET_5952 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M137 PAD NET_80 NET_5947 NET_1364 P33 l=0.300u w=30.000u
M138 NET_5953 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M139 NET_5958 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M140 VDD33 NET_83 NET_100 VDD33 P33 l=0.300u w=5.000u
M141 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_3505 NET_5941 NET_1364 P33 l=0.300u w=30.000u
M143 NET_5941 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M144 VDD33 NET_3505 NET_5945 NET_1364 P33 l=0.300u w=30.000u
M145 NET_5945 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M146 VDD33 VSS NET_3505 VDD33 P33 l=0.300u w=5.000u
M147 VDD33 NET_83 NET_104 VDD33 P33 l=0.300u w=5.000u
M148 NET_5933 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M149 NET_5933 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M150 NET_5938 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M151 NET_5938 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M152 NET_83 NET_104 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_79 NET_77 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_77 NET_79 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_65 NET_5931 NET_1364 P33 l=0.300u w=30.000u
M156 NET_5931 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M157 PAD NET_80 NET_5929 NET_1364 P33 l=0.300u w=30.000u
M158 VDD33 NET_65 NET_5936 NET_1364 P33 l=0.300u w=30.000u
M159 NET_5936 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M160 PAD NET_80 NET_5934 NET_1364 P33 l=0.300u w=30.000u
M161 NET_5920 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M162 NET_5924 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M163 NET_5929 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M164 NET_5934 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M165 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M166 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_68 NET_65 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_68 NET_69 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_69 NET_68 VDD33 P33 l=0.300u w=5.000u
M170 PAD NET_80 NET_5918 NET_1364 P33 l=0.300u w=30.000u
M171 NET_5918 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M172 PAD NET_80 NET_5922 NET_1364 P33 l=0.300u w=30.000u
M173 NET_5922 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M174 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M175 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M176 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M177 VDD33 NET_45 NET_3547 VDD33 P33 l=0.300u w=5.000u
M178 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M179 NET_5943 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M180 NET_5947 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M181 NET_5920 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M182 NET_5924 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
M184 PAD VDD33 NET_80 NET_1364 P33 l=0.350u w=10.000u
R1 PAD NET_45 300.135
.ends PBSU8

.subckt PBSU4   PAD I OEN C FP
M1 VSS NET_108 NET_85 VSS N18 l=0.180u w=2.000u
M2 VSS NET_108 NET_85 VSS N18 l=0.180u w=2.000u
M3 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M5 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M7 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 NET_79 NET_74 VSS VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_79 VSS N18 l=0.180u w=2.000u
M21 VDD NET_108 NET_85 VDD P18 l=0.180u w=5.000u
M22 VDD NET_108 NET_85 VDD P18 l=0.180u w=5.000u
M23 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M25 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M27 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M29 NET_5968 OEN NET_74 VDD P18 l=0.180u w=5.000u
M30 NET_5968 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_74 NET_79 VDD P18 l=0.180u w=5.000u
M32 VDD NET_74 NET_79 VDD P18 l=0.180u w=5.000u
M33 NET_79 NET_74 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_79 VDD P18 l=0.180u w=5.000u
M35 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M39 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M40 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M41 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M42 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_25 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M77 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M78 NET_88 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M79 NET_11 NET_88 NET_98 VSS N33 l=0.350u w=8.000u
M80 NET_11 NET_88 VSS VSS N33 l=0.350u w=8.000u
M81 VDD33 NET_98 NET_11 VSS N33 l=0.350u w=0.820u
M82 VSS NET_98 NET_108 VSS N33 l=0.350u w=2.000u
M83 VSS NET_98 NET_108 VSS N33 l=0.350u w=2.000u
M84 NET_95 NET_10 VSS VSS N33 l=0.350u w=4.000u
M85 NET_95 NET_10 VSS VSS N33 l=0.350u w=4.000u
M86 VSS NET_10 NET_95 VSS N33 l=0.350u w=4.000u
M87 VSS NET_49 NET_46 VSS N33 l=0.350u w=8.000u
M88 VSS NET_49 NET_46 VSS N33 l=0.350u w=8.000u
M89 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M90 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M91 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M92 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M93 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M94 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M95 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M96 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M97 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M98 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M99 NET_63 NET_3515 NET_61 VSS N33 l=0.350u w=8.000u
M100 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M101 NET_93 NET_79 VSS VSS N33 l=0.350u w=8.000u
M102 VSS NET_74 NET_10 VSS N33 l=0.350u w=8.000u
M103 VSS NET_74 NET_10 VSS N33 l=0.350u w=8.000u
M104 NET_93 NET_79 VSS VSS N33 l=0.350u w=8.000u
M105 VSS NET_98 NET_3556 VDD33 P33 l=0.300u w=5.100u
M106 VSS NET_98 NET_3556 VDD33 P33 l=0.300u w=5.100u
M107 VDD33 VDD NET_45 NET_1365 P33 l=1.070u w=5.000u
M108 NET_5951 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M109 NET_5951 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M110 NET_5953 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M111 NET_5953 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M112 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M113 NET_98 NET_88 NET_3556 VDD33 P33 l=0.300u w=5.000u
M114 NET_98 NET_88 NET_3556 VDD33 P33 l=0.300u w=5.000u
M115 NET_3556 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M116 NET_3556 NET_98 VSS VDD33 P33 l=0.300u w=5.100u
M117 PAD NET_61 NET_5942 NET_1365 P33 l=0.300u w=30.000u
M118 NET_5942 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M119 VDD33 NET_3515 NET_5940 NET_1365 P33 l=0.300u w=30.000u
M120 NET_5940 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M121 PAD NET_61 NET_5947 NET_1365 P33 l=0.300u w=30.000u
M122 NET_5947 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M123 VDD33 NET_3515 NET_5945 NET_1365 P33 l=0.300u w=30.000u
M124 NET_5945 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M125 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M126 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M127 NET_108 NET_98 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M129 NET_95 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M130 NET_95 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M131 PAD NET_61 NET_5938 NET_1365 P33 l=0.300u w=30.000u
M132 NET_5938 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M133 NET_5936 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M134 NET_5936 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M135 PAD NET_61 NET_5928 NET_1365 P33 l=0.300u w=30.000u
M136 PAD NET_61 NET_5943 NET_1365 P33 l=0.300u w=30.000u
M137 NET_5943 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M138 NET_5937 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M139 NET_5937 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M140 PAD NET_61 NET_5932 NET_1365 P33 l=0.300u w=30.000u
M141 VDD33 VSS NET_3515 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_10 NET_95 VDD33 P33 l=0.300u w=5.000u
M143 NET_10 NET_93 VDD33 VDD33 P33 l=0.300u w=5.000u
M144 VDD33 NET_10 NET_93 VDD33 P33 l=0.300u w=5.000u
M145 VDD33 NET_3515 NET_5926 NET_1365 P33 l=0.300u w=30.000u
M146 NET_5926 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M147 NET_5918 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M148 NET_5918 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M149 VDD33 NET_3515 NET_5930 NET_1365 P33 l=0.300u w=30.000u
M150 NET_5930 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M151 NET_5923 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M152 NET_5923 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M153 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_3515 NET_5916 NET_1365 P33 l=0.300u w=30.000u
M156 NET_5916 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M157 PAD NET_61 NET_5914 NET_1365 P33 l=0.300u w=30.000u
M158 NET_5914 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M159 NET_5905 NET_46 VDD33 NET_1365 P33 l=0.300u w=30.000u
M160 VDD33 NET_3515 NET_5921 NET_1365 P33 l=0.300u w=30.000u
M161 NET_5921 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M162 PAD NET_61 NET_5919 NET_1365 P33 l=0.300u w=30.000u
M163 NET_5919 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M164 NET_5909 NET_46 VDD33 NET_1365 P33 l=0.300u w=30.000u
M165 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M169 PAD NET_61 NET_5903 NET_1365 P33 l=0.300u w=30.000u
M170 NET_5903 NET_46 VDD33 NET_1365 P33 l=0.300u w=30.000u
M171 PAD NET_61 NET_5907 NET_1365 P33 l=0.300u w=30.000u
M172 NET_5907 NET_46 VDD33 NET_1365 P33 l=0.300u w=30.000u
M173 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M174 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M175 VDD33 PAD NET_1365 NET_1365 P33 l=0.350u w=5.000u
M176 VDD33 NET_45 NET_3556 VDD33 P33 l=0.300u w=5.000u
M177 NET_3556 NET_98 VSS VDD33 P33 l=0.300u w=5.100u
M178 PAD VDD33 NET_61 NET_1365 P33 l=0.350u w=10.000u
M179 PAD VDD33 NET_1365 NET_1365 P33 l=0.350u w=15.000u
M180 NET_5928 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M181 NET_5905 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M182 NET_5932 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M183 NET_5909 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
R1 PAD NET_45 300.135
.ends PBSU4

.subckt PBSU24   PAD OEN I C FP
M1 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M3 C NET_92 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M5 C NET_92 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_95 NET_92 VSS N18 l=0.180u w=2.000u
M8 VSS NET_95 NET_92 VSS N18 l=0.180u w=2.000u
M9 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M10 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M11 NET_52 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_52 NET_53 NET_51 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M17 NET_56 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_56 VSS N18 l=0.180u w=2.000u
M19 NET_61 NET_56 VSS VSS N18 l=0.180u w=2.000u
M20 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M21 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_95 NET_92 VDD P18 l=0.180u w=5.000u
M23 VDD NET_95 NET_92 VDD P18 l=0.180u w=5.000u
M24 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M25 C NET_92 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M27 C NET_92 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M32 NET_5982 OEN NET_56 VDD P18 l=0.180u w=5.000u
M33 NET_5982 I VDD VDD P18 l=0.180u w=5.000u
M34 NET_61 NET_56 VDD VDD P18 l=0.180u w=5.000u
M35 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M36 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M37 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M38 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_53 NET_51 VDD P18 l=0.180u w=5.000u
M41 NET_51 NET_53 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_100 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_100 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_100 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_100 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M77 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M78 NET_105 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M79 NET_11 NET_105 NET_109 VSS N33 l=0.350u w=8.000u
M80 NET_11 NET_105 VSS VSS N33 l=0.350u w=8.000u
M81 VDD33 NET_109 NET_11 VSS N33 l=0.350u w=0.820u
M82 VSS NET_109 NET_95 VSS N33 l=0.350u w=2.000u
M83 VSS NET_109 NET_95 VSS N33 l=0.350u w=2.000u
M84 NET_100 NET_10 VSS VSS N33 l=0.350u w=8.000u
M85 NET_100 NET_10 VSS VSS N33 l=0.350u w=8.000u
M86 VSS NET_10 NET_100 VSS N33 l=0.350u w=8.000u
M87 VSS NET_68 NET_65 VSS N33 l=0.350u w=8.000u
M88 VSS NET_68 NET_65 VSS N33 l=0.350u w=8.000u
M89 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M90 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M91 NET_68 NET_51 VSS VSS N33 l=0.350u w=5.330u
M92 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M93 NET_69 NET_47 VSS VSS N33 l=0.350u w=5.330u
M94 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M95 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M96 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M97 VSS NET_53 NET_77 VSS N33 l=0.350u w=7.440u
M98 NET_77 NET_53 VSS VSS N33 l=0.350u w=7.440u
M99 NET_82 NET_3503 NET_80 VSS N33 l=0.350u w=8.000u
M100 NET_82 NET_79 VSS VSS N33 l=0.350u w=8.000u
M101 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M102 VSS NET_56 NET_10 VSS N33 l=0.350u w=8.000u
M103 VSS NET_56 NET_10 VSS N33 l=0.350u w=8.000u
M104 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M105 NET_5963 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M106 NET_5963 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M107 NET_5965 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M108 NET_5965 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M109 VDD33 VDD NET_45 NET_1365 P33 l=1.070u w=5.000u
M110 VSS NET_109 NET_3544 VDD33 P33 l=0.300u w=5.100u
M111 VSS NET_109 NET_3544 VDD33 P33 l=0.300u w=5.100u
M112 VDD NET_109 NET_95 VDD P33 l=0.300u w=5.000u
M113 PAD NET_80 NET_5956 NET_1365 P33 l=0.300u w=30.000u
M114 NET_5956 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M115 VDD33 NET_65 NET_5954 NET_1365 P33 l=0.300u w=30.000u
M116 NET_5954 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M117 PAD NET_80 NET_5961 NET_1365 P33 l=0.300u w=30.000u
M118 NET_5961 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M119 VDD33 NET_65 NET_5959 NET_1365 P33 l=0.300u w=30.000u
M120 NET_5959 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M121 NET_109 NET_105 NET_3544 VDD33 P33 l=0.300u w=5.000u
M122 NET_109 NET_105 NET_3544 VDD33 P33 l=0.300u w=5.000u
M123 NET_3544 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 NET_3544 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M125 VDD NET_109 NET_95 VDD P33 l=0.300u w=5.000u
M126 VDD NET_109 NET_95 VDD P33 l=0.300u w=5.000u
M127 NET_95 NET_109 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_109 NET_95 VDD P33 l=0.300u w=5.000u
M129 PAD NET_80 NET_5952 NET_1365 P33 l=0.300u w=30.000u
M130 PAD NET_80 NET_5957 NET_1365 P33 l=0.300u w=30.000u
M131 NET_5950 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M132 NET_5950 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M133 PAD NET_80 NET_5942 NET_1365 P33 l=0.300u w=30.000u
M134 NET_5951 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M135 NET_5951 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M136 PAD NET_80 NET_5946 NET_1365 P33 l=0.300u w=30.000u
M137 NET_100 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_100 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 NET_5952 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M140 NET_5957 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M141 VDD33 NET_65 NET_5940 NET_1365 P33 l=0.300u w=30.000u
M142 NET_5940 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M143 VDD33 NET_65 NET_5944 NET_1365 P33 l=0.300u w=30.000u
M144 NET_5944 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M145 VDD33 NET_10 NET_100 VDD33 P33 l=0.300u w=5.000u
M146 NET_5932 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M147 NET_5932 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M148 NET_5937 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M149 NET_5937 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M150 VDD33 VSS NET_3503 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_10 NET_104 VDD33 P33 l=0.300u w=5.000u
M152 NET_10 NET_104 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_65 NET_5930 NET_1365 P33 l=0.300u w=30.000u
M154 NET_5930 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M155 PAD NET_80 NET_5928 NET_1365 P33 l=0.300u w=30.000u
M156 VDD33 NET_65 NET_5935 NET_1365 P33 l=0.300u w=30.000u
M157 NET_5935 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M158 PAD NET_80 NET_5933 NET_1365 P33 l=0.300u w=30.000u
M159 VDD33 NET_79 NET_77 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_77 NET_79 VDD33 P33 l=0.300u w=5.000u
M161 NET_5919 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M162 NET_5923 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M163 NET_5928 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M164 NET_5933 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M165 PAD NET_80 NET_5917 NET_1365 P33 l=0.300u w=30.000u
M166 NET_5917 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M167 PAD NET_80 NET_5921 NET_1365 P33 l=0.300u w=30.000u
M168 NET_5921 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M169 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M170 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M171 VDD33 PAD NET_1365 NET_1365 P33 l=0.350u w=5.000u
M172 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M173 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_68 NET_65 VDD33 P33 l=0.300u w=5.000u
M175 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_68 NET_65 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_68 NET_69 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_69 NET_68 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_45 NET_3544 VDD33 P33 l=0.300u w=5.000u
M180 NET_3544 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M181 NET_5942 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M182 NET_5946 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M183 NET_5919 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M184 NET_5923 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M185 PAD VDD33 NET_80 NET_1365 P33 l=0.350u w=10.000u
M186 PAD VDD33 NET_1365 NET_1365 P33 l=0.350u w=15.000u
R1 PAD NET_45 300.135
.ends PBSU24

.subckt PBSU2   PAD OEN I C FP
M1 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M3 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M5 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M8 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M9 VSS NET_71 NET_67 VSS N18 l=0.180u w=4.000u
M10 VSS NET_71 NET_67 VSS N18 l=0.180u w=4.000u
M11 NET_72 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_72 NET_73 NET_71 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M17 NET_76 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_76 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_76 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M22 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M23 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M25 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M27 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M29 NET_5957 OEN NET_76 VDD P18 l=0.180u w=5.000u
M30 NET_5957 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M32 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M33 NET_46 NET_76 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M35 NET_71 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_71 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_73 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_73 VDD P18 l=0.180u w=5.000u
M39 VDD NET_71 NET_67 VDD P18 l=0.180u w=5.000u
M40 VDD NET_71 NET_67 VDD P18 l=0.180u w=5.000u
M41 VDD NET_73 NET_71 VDD P18 l=0.180u w=5.000u
M42 NET_71 NET_73 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_25 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_45 VDD33 NET_86 VSS N33 l=0.350u w=8.000u
M77 NET_45 VDD33 NET_86 VSS N33 l=0.350u w=8.000u
M78 NET_86 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M79 NET_85 NET_86 NET_90 VSS N33 l=0.350u w=8.000u
M80 NET_85 NET_86 VSS VSS N33 l=0.350u w=8.000u
M81 NET_85 NET_90 VDD33 VSS N33 l=0.350u w=0.820u
M82 VSS NET_90 NET_108 VSS N33 l=0.350u w=2.000u
M83 VSS NET_90 NET_108 VSS N33 l=0.350u w=2.000u
M84 VSS NET_47 NET_95 VSS N33 l=0.350u w=4.000u
M85 VSS NET_47 NET_95 VSS N33 l=0.350u w=4.000u
M86 NET_52 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_52 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_73 NET_50 VSS N33 l=0.350u w=7.440u
M89 NET_50 NET_73 VSS VSS N33 l=0.350u w=7.440u
M90 NET_55 NET_3510 NET_53 VSS N33 l=0.350u w=8.000u
M91 NET_55 NET_52 VSS VSS N33 l=0.350u w=8.000u
M92 VSS NET_71 NET_56 VSS N33 l=0.350u w=5.330u
M93 VSS NET_71 NET_56 VSS N33 l=0.350u w=5.330u
M94 NET_56 NET_71 VSS VSS N33 l=0.350u w=5.330u
M95 VSS NET_67 NET_57 VSS N33 l=0.350u w=5.330u
M96 NET_57 NET_67 VSS VSS N33 l=0.350u w=5.330u
M97 VSS NET_67 NET_57 VSS N33 l=0.350u w=5.330u
M98 NET_94 NET_46 VSS VSS N33 l=0.350u w=8.000u
M99 VSS NET_76 NET_47 VSS N33 l=0.350u w=8.000u
M100 VSS NET_76 NET_47 VSS N33 l=0.350u w=8.000u
M101 VSS NET_56 NET_64 VSS N33 l=0.350u w=4.000u
M102 VSS NET_56 NET_64 VSS N33 l=0.350u w=4.000u
M103 NET_94 NET_46 VSS VSS N33 l=0.350u w=8.000u
M104 VSS NET_90 NET_3564 VDD33 P33 l=0.300u w=5.100u
M105 VSS NET_90 NET_3564 VDD33 P33 l=0.300u w=5.100u
M106 NET_5938 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M107 NET_5938 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M108 NET_5940 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M109 NET_5940 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M110 VDD33 VDD NET_45 NET_1364 P33 l=1.070u w=5.000u
M111 VDD NET_90 NET_108 VDD P33 l=0.300u w=5.000u
M112 NET_90 NET_86 NET_3564 VDD33 P33 l=0.300u w=5.000u
M113 NET_90 NET_86 NET_3564 VDD33 P33 l=0.300u w=5.000u
M114 NET_3564 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M115 NET_3564 NET_90 VSS VDD33 P33 l=0.300u w=5.100u
M116 PAD NET_53 NET_5931 NET_1364 P33 l=0.300u w=30.000u
M117 NET_5931 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_3510 NET_5929 NET_1364 P33 l=0.300u w=30.000u
M119 NET_5929 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M120 PAD NET_53 NET_5936 NET_1364 P33 l=0.300u w=30.000u
M121 NET_5936 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M122 VDD33 NET_3510 NET_5934 NET_1364 P33 l=0.300u w=30.000u
M123 NET_5934 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M124 VDD NET_90 NET_108 VDD P33 l=0.300u w=5.000u
M125 VDD NET_90 NET_108 VDD P33 l=0.300u w=5.000u
M126 NET_108 NET_90 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_90 NET_108 VDD P33 l=0.300u w=5.000u
M128 VDD33 NET_47 NET_95 VDD33 P33 l=0.300u w=5.000u
M129 PAD NET_53 NET_5927 NET_1364 P33 l=0.300u w=30.000u
M130 NET_5927 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M131 NET_5925 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M132 NET_5925 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M133 PAD NET_53 NET_5917 NET_1364 P33 l=0.300u w=30.000u
M134 PAD NET_53 NET_5932 NET_1364 P33 l=0.300u w=30.000u
M135 NET_5932 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M136 NET_5926 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M137 NET_5926 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M138 PAD NET_53 NET_5921 NET_1364 P33 l=0.300u w=30.000u
M139 VDD33 VSS NET_3510 VDD33 P33 l=0.300u w=5.000u
M140 NET_47 NET_94 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_47 NET_94 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_3510 NET_5915 NET_1364 P33 l=0.300u w=30.000u
M143 NET_5915 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M144 NET_5907 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M145 NET_5907 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M146 VDD33 NET_3510 NET_5919 NET_1364 P33 l=0.300u w=30.000u
M147 NET_5919 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M148 NET_5912 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M149 NET_5912 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M150 VDD33 NET_52 NET_50 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_50 NET_52 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_3510 NET_5905 NET_1364 P33 l=0.300u w=30.000u
M153 NET_5905 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M154 PAD NET_53 NET_5903 NET_1364 P33 l=0.300u w=30.000u
M155 NET_5903 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M156 NET_5894 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M157 VDD33 NET_3510 NET_5910 NET_1364 P33 l=0.300u w=30.000u
M158 NET_5910 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M159 PAD NET_53 NET_5908 NET_1364 P33 l=0.300u w=30.000u
M160 NET_5908 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M161 NET_5898 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M162 VDD33 NET_56 NET_57 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_57 NET_56 VDD33 P33 l=0.300u w=5.000u
M164 NET_64 NET_56 VDD33 VDD33 P33 l=0.300u w=5.000u
M165 NET_64 NET_56 VDD33 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_56 NET_64 VDD33 P33 l=0.300u w=5.000u
M167 PAD NET_53 NET_5892 NET_1364 P33 l=0.300u w=30.000u
M168 NET_5892 NET_64 VDD33 NET_1364 P33 l=0.300u w=30.000u
M169 PAD NET_53 NET_5896 NET_1364 P33 l=0.300u w=30.000u
M170 NET_5896 NET_64 VDD33 NET_1364 P33 l=0.300u w=30.000u
M171 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M172 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M173 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M174 VDD33 NET_45 NET_3564 VDD33 P33 l=0.300u w=5.000u
M175 NET_3564 NET_90 VSS VDD33 P33 l=0.300u w=5.100u
M176 PAD VDD33 NET_53 NET_1364 P33 l=0.350u w=10.000u
M177 NET_5917 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M178 NET_5894 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M179 NET_5921 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M180 NET_5898 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
R1 PAD NET_45 300.135
.ends PBSU2

.subckt PBSU16   PAD OEN I C FP
M1 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M3 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M5 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M8 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M9 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M10 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M11 NET_52 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_52 NET_53 NET_51 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M17 NET_56 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_56 VSS N18 l=0.180u w=2.000u
M19 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M20 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M21 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M23 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M24 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M25 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M27 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M30 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M33 NET_5983 OEN NET_56 VDD P18 l=0.180u w=5.000u
M34 NET_5983 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_61 NET_56 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M37 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M38 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M39 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_53 NET_51 VDD P18 l=0.180u w=5.000u
M42 NET_51 NET_53 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_100 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_100 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M77 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M78 NET_105 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M79 NET_85 NET_105 NET_109 VSS N33 l=0.350u w=8.000u
M80 NET_85 NET_105 VSS VSS N33 l=0.350u w=8.000u
M81 NET_85 NET_109 VDD33 VSS N33 l=0.350u w=0.820u
M82 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M83 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M84 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M85 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M86 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M87 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M88 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M89 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M90 NET_68 NET_51 VSS VSS N33 l=0.350u w=5.330u
M91 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M92 NET_69 NET_47 VSS VSS N33 l=0.350u w=5.330u
M93 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M94 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M95 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M96 VSS NET_53 NET_77 VSS N33 l=0.350u w=7.440u
M97 NET_77 NET_53 VSS VSS N33 l=0.350u w=7.440u
M98 NET_82 NET_3505 NET_80 VSS N33 l=0.350u w=8.000u
M99 NET_82 NET_79 VSS VSS N33 l=0.350u w=8.000u
M100 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M101 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M102 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M103 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M104 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M105 NET_5964 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M106 NET_5964 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M107 NET_5966 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M108 NET_5966 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M109 VDD33 VDD NET_45 NET_1364 P33 l=1.070u w=5.000u
M110 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M111 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M112 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M113 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M114 NET_3547 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M115 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M116 PAD NET_80 NET_5957 NET_1364 P33 l=0.300u w=30.000u
M117 NET_5957 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_3505 NET_5955 NET_1364 P33 l=0.300u w=30.000u
M119 NET_5955 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M120 PAD NET_80 NET_5962 NET_1364 P33 l=0.300u w=30.000u
M121 NET_5962 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M122 VDD33 NET_3505 NET_5960 NET_1364 P33 l=0.300u w=30.000u
M123 NET_5960 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M124 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M125 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M126 NET_96 NET_109 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M128 PAD NET_80 NET_5953 NET_1364 P33 l=0.300u w=30.000u
M129 PAD NET_80 NET_5958 NET_1364 P33 l=0.300u w=30.000u
M130 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M131 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M132 NET_5951 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M133 NET_5951 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M134 PAD NET_80 NET_5943 NET_1364 P33 l=0.300u w=30.000u
M135 NET_5952 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M136 NET_5952 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M137 PAD NET_80 NET_5947 NET_1364 P33 l=0.300u w=30.000u
M138 NET_5953 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M139 NET_5958 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M140 VDD33 NET_83 NET_100 VDD33 P33 l=0.300u w=5.000u
M141 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_65 NET_5941 NET_1364 P33 l=0.300u w=30.000u
M143 NET_5941 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M144 VDD33 NET_65 NET_5945 NET_1364 P33 l=0.300u w=30.000u
M145 NET_5945 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M146 VDD33 VSS NET_3505 VDD33 P33 l=0.300u w=5.000u
M147 VDD33 NET_83 NET_104 VDD33 P33 l=0.300u w=5.000u
M148 NET_5933 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M149 NET_5933 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M150 NET_5938 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M151 NET_5938 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M152 NET_83 NET_104 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_79 NET_77 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_77 NET_79 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_65 NET_5931 NET_1364 P33 l=0.300u w=30.000u
M156 NET_5931 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M157 PAD NET_80 NET_5929 NET_1364 P33 l=0.300u w=30.000u
M158 VDD33 NET_65 NET_5936 NET_1364 P33 l=0.300u w=30.000u
M159 NET_5936 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M160 PAD NET_80 NET_5934 NET_1364 P33 l=0.300u w=30.000u
M161 NET_5920 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M162 NET_5924 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M163 NET_5929 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M164 NET_5934 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M165 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M166 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_68 NET_65 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_68 NET_69 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_69 NET_68 VDD33 P33 l=0.300u w=5.000u
M170 PAD NET_80 NET_5918 NET_1364 P33 l=0.300u w=30.000u
M171 NET_5918 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M172 PAD NET_80 NET_5922 NET_1364 P33 l=0.300u w=30.000u
M173 NET_5922 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M174 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M175 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M176 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M177 VDD33 NET_45 NET_3547 VDD33 P33 l=0.300u w=5.000u
M178 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M179 NET_5943 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M180 NET_5947 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M181 NET_5920 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M182 NET_5924 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
M184 PAD VDD33 NET_80 NET_1364 P33 l=0.350u w=10.000u
R1 PAD NET_45 300.135
.ends PBSU16

.subckt PBSU12   PAD OEN I C FP
M1 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M3 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M5 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M8 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M9 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M10 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M11 NET_52 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_52 NET_53 NET_51 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M17 NET_56 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_56 VSS N18 l=0.180u w=2.000u
M19 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M20 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M21 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M23 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M24 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M25 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M27 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M30 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M33 NET_5983 OEN NET_56 VDD P18 l=0.180u w=5.000u
M34 NET_5983 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_61 NET_56 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M37 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M38 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M39 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_53 NET_51 VDD P18 l=0.180u w=5.000u
M42 NET_51 NET_53 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_100 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_100 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M77 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M78 NET_105 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M79 NET_85 NET_105 NET_109 VSS N33 l=0.350u w=8.000u
M80 NET_85 NET_105 VSS VSS N33 l=0.350u w=8.000u
M81 NET_85 NET_109 VDD33 VSS N33 l=0.350u w=0.820u
M82 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M83 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M84 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M85 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M86 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M87 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M88 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M89 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M90 NET_68 NET_51 VSS VSS N33 l=0.350u w=5.330u
M91 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M92 NET_69 NET_47 VSS VSS N33 l=0.350u w=5.330u
M93 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M94 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M95 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M96 VSS NET_53 NET_77 VSS N33 l=0.350u w=7.440u
M97 NET_77 NET_53 VSS VSS N33 l=0.350u w=7.440u
M98 NET_82 NET_3505 NET_80 VSS N33 l=0.350u w=8.000u
M99 NET_82 NET_79 VSS VSS N33 l=0.350u w=8.000u
M100 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M101 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M102 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M103 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M104 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M105 NET_5964 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M106 NET_5964 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M107 NET_5966 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M108 NET_5966 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M109 VDD33 VDD NET_45 NET_1364 P33 l=1.070u w=5.000u
M110 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M111 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M112 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M113 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M114 NET_3547 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M115 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M116 PAD NET_80 NET_5957 NET_1364 P33 l=0.300u w=30.000u
M117 NET_5957 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_3505 NET_5955 NET_1364 P33 l=0.300u w=30.000u
M119 NET_5955 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M120 PAD NET_80 NET_5962 NET_1364 P33 l=0.300u w=30.000u
M121 NET_5962 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M122 VDD33 NET_3505 NET_5960 NET_1364 P33 l=0.300u w=30.000u
M123 NET_5960 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M124 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M125 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M126 NET_96 NET_109 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M128 PAD NET_80 NET_5953 NET_1364 P33 l=0.300u w=30.000u
M129 PAD NET_80 NET_5958 NET_1364 P33 l=0.300u w=30.000u
M130 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M131 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M132 NET_5951 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M133 NET_5951 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M134 PAD NET_80 NET_5943 NET_1364 P33 l=0.300u w=30.000u
M135 NET_5952 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M136 NET_5952 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M137 PAD NET_80 NET_5947 NET_1364 P33 l=0.300u w=30.000u
M138 NET_5953 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M139 NET_5958 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M140 VDD33 NET_83 NET_100 VDD33 P33 l=0.300u w=5.000u
M141 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_65 NET_5941 NET_1364 P33 l=0.300u w=30.000u
M143 NET_5941 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M144 VDD33 NET_65 NET_5945 NET_1364 P33 l=0.300u w=30.000u
M145 NET_5945 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M146 VDD33 VSS NET_3505 VDD33 P33 l=0.300u w=5.000u
M147 VDD33 NET_83 NET_104 VDD33 P33 l=0.300u w=5.000u
M148 NET_5933 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M149 NET_5933 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M150 NET_5938 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M151 NET_5938 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M152 NET_83 NET_104 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_79 NET_77 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_77 NET_79 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_65 NET_5931 NET_1364 P33 l=0.300u w=30.000u
M156 NET_5931 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M157 PAD NET_80 NET_5929 NET_1364 P33 l=0.300u w=30.000u
M158 VDD33 NET_65 NET_5936 NET_1364 P33 l=0.300u w=30.000u
M159 NET_5936 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M160 PAD NET_80 NET_5934 NET_1364 P33 l=0.300u w=30.000u
M161 NET_5920 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M162 NET_5924 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M163 NET_5929 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M164 NET_5934 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M165 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M166 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_68 NET_65 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_68 NET_69 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_69 NET_68 VDD33 P33 l=0.300u w=5.000u
M170 PAD NET_80 NET_5918 NET_1364 P33 l=0.300u w=30.000u
M171 NET_5918 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M172 PAD NET_80 NET_5922 NET_1364 P33 l=0.300u w=30.000u
M173 NET_5922 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M174 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M175 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M176 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M177 VDD33 NET_45 NET_3547 VDD33 P33 l=0.300u w=5.000u
M178 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M179 NET_5943 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M180 NET_5947 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M181 NET_5920 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M182 NET_5924 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
M184 PAD VDD33 NET_80 NET_1364 P33 l=0.350u w=10.000u
R1 PAD NET_45 300.135
.ends PBSU12

.subckt PBSDL8   PAD I OEN C FP
M1 VSS NET_107 NET_85 VSS N18 l=0.180u w=2.000u
M2 VSS NET_107 NET_85 VSS N18 l=0.180u w=2.000u
M3 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M5 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M7 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M11 NET_53 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_53 VSS N18 l=0.180u w=2.000u
M13 VSS NET_75 NET_71 VSS N18 l=0.180u w=4.000u
M14 VSS NET_75 NET_71 VSS N18 l=0.180u w=4.000u
M15 NET_76 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_76 NET_77 NET_75 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_77 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_77 VSS N18 l=0.180u w=2.000u
M19 VSS NET_53 NET_47 VSS N18 l=0.180u w=2.000u
M20 VSS NET_53 NET_47 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_85 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_85 VDD P18 l=0.180u w=5.000u
M23 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M25 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M27 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M29 NET_5940 OEN NET_53 VDD P18 l=0.180u w=5.000u
M30 NET_5940 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_53 NET_47 VDD P18 l=0.180u w=5.000u
M32 VDD NET_53 NET_47 VDD P18 l=0.180u w=5.000u
M33 NET_47 NET_53 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_53 NET_47 VDD P18 l=0.180u w=5.000u
M35 NET_75 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_75 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_77 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_77 VDD P18 l=0.180u w=5.000u
M39 VDD NET_75 NET_71 VDD P18 l=0.180u w=5.000u
M40 VDD NET_75 NET_71 VDD P18 l=0.180u w=5.000u
M41 VDD NET_77 NET_75 VDD P18 l=0.180u w=5.000u
M42 NET_75 NET_77 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_25 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_93 NET_47 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_46 NET_94 VSS N33 l=0.350u w=8.000u
M78 VSS NET_46 NET_94 VSS N33 l=0.350u w=8.000u
M79 NET_52 OEN VSS VSS N33 l=0.350u w=7.440u
M80 NET_52 OEN VSS VSS N33 l=0.350u w=7.440u
M81 VSS NET_77 NET_50 VSS N33 l=0.350u w=7.440u
M82 NET_50 NET_77 VSS VSS N33 l=0.350u w=7.440u
M83 NET_59 NET_60 VSS VSS N33 l=0.350u w=4.600u
M84 VSS NET_75 NET_60 VSS N33 l=0.350u w=5.330u
M85 VSS NET_75 NET_60 VSS N33 l=0.350u w=5.330u
M86 NET_60 NET_75 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_71 NET_61 VSS N33 l=0.350u w=5.330u
M88 NET_61 NET_71 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_71 NET_61 VSS N33 l=0.350u w=5.330u
M90 NET_69 NET_3502 NET_67 VSS N33 l=0.350u w=8.000u
M91 NET_69 NET_52 VSS VSS N33 l=0.350u w=8.000u
M92 NET_93 NET_47 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_53 NET_46 VSS N33 l=0.350u w=8.000u
M94 VSS NET_53 NET_46 VSS N33 l=0.350u w=8.000u
M95 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M97 NET_88 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M98 NET_84 NET_88 NET_97 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_88 VSS VSS N33 l=0.350u w=8.000u
M100 VDD33 NET_97 NET_84 VSS N33 l=0.350u w=0.820u
M101 NET_88 VDD33 VSS VSS N33 l=4.550u w=0.800u
M102 VSS NET_97 NET_107 VSS N33 l=0.350u w=2.000u
M103 VSS NET_97 NET_107 VSS N33 l=0.350u w=2.000u
M104 NET_5921 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M105 NET_5921 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M106 NET_5923 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M107 NET_5923 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M108 NET_1365 NET_1365 NET_1365 NET_1365 P33 l=1.070u w=5.000u
M109 VSS NET_97 NET_3551 VDD33 P33 l=0.300u w=5.100u
M110 VSS NET_97 NET_3551 VDD33 P33 l=0.300u w=5.100u
M111 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M112 PAD NET_67 NET_5914 NET_1365 P33 l=0.300u w=30.000u
M113 NET_5914 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M114 VDD33 NET_3502 NET_5912 NET_1365 P33 l=0.300u w=30.000u
M115 NET_5912 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M116 PAD NET_67 NET_5919 NET_1365 P33 l=0.300u w=30.000u
M117 NET_5919 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M118 VDD33 NET_3502 NET_5917 NET_1365 P33 l=0.300u w=30.000u
M119 NET_5917 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M120 NET_97 NET_88 NET_3551 VDD33 P33 l=0.300u w=5.000u
M121 NET_97 NET_88 NET_3551 VDD33 P33 l=0.300u w=5.000u
M122 NET_3551 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 NET_3551 NET_97 VSS VDD33 P33 l=0.300u w=5.100u
M124 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M125 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M126 NET_107 NET_97 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M128 PAD NET_67 NET_5910 NET_1365 P33 l=0.300u w=30.000u
M129 NET_5910 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M130 NET_5908 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M131 NET_5908 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M132 PAD NET_67 NET_5900 NET_1365 P33 l=0.300u w=30.000u
M133 PAD NET_67 NET_5915 NET_1365 P33 l=0.300u w=30.000u
M134 NET_5915 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M135 NET_5909 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M136 NET_5909 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M137 PAD NET_67 NET_5904 NET_1365 P33 l=0.300u w=30.000u
M138 NET_94 NET_46 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 VDD33 NET_3502 NET_5898 NET_1365 P33 l=0.300u w=30.000u
M140 NET_5898 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M141 NET_5890 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M142 NET_5890 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M143 VDD33 NET_3502 NET_5902 NET_1365 P33 l=0.300u w=30.000u
M144 NET_5902 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M145 NET_5895 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M146 NET_5895 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M147 VDD33 VSS NET_3502 VDD33 P33 l=0.300u w=5.000u
M148 NET_46 NET_93 VDD33 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_46 NET_93 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_59 NET_5888 NET_1365 P33 l=0.300u w=30.000u
M151 NET_5888 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M152 PAD NET_67 NET_5886 NET_1365 P33 l=0.300u w=30.000u
M153 NET_5886 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M154 NET_5877 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M155 VDD33 NET_59 NET_5893 NET_1365 P33 l=0.300u w=30.000u
M156 NET_5893 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M157 PAD NET_67 NET_5891 NET_1365 P33 l=0.300u w=30.000u
M158 NET_5891 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M159 NET_5881 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M160 VDD33 NET_52 NET_50 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_50 NET_52 VDD33 P33 l=0.300u w=5.000u
M162 PAD NET_67 NET_5875 NET_1365 P33 l=0.300u w=30.000u
M163 NET_5875 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M164 PAD NET_67 NET_5879 NET_1365 P33 l=0.300u w=30.000u
M165 NET_5879 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M166 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M167 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M168 VDD33 PAD NET_1365 NET_1365 P33 l=0.350u w=5.000u
M169 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M171 NET_59 NET_60 VDD33 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_60 NET_61 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_61 NET_60 VDD33 P33 l=0.300u w=5.000u
M175 PAD VDD33 NET_67 NET_1365 P33 l=0.350u w=10.000u
M176 PAD VDD33 NET_1365 NET_1365 P33 l=0.350u w=15.000u
M177 NET_5900 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M178 NET_5877 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M179 NET_5904 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M180 NET_5881 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M181 VDD33 NET_45 NET_3551 VDD33 P33 l=0.300u w=5.000u
M182 NET_3551 NET_97 VSS VDD33 P33 l=0.300u w=5.100u
R1 PAD NET_45 300.135
.ends PBSDL8

.subckt PBSDL24   PAD I OEN C FP
M1 VSS NET_107 NET_85 VSS N18 l=0.180u w=2.000u
M2 VSS NET_107 NET_85 VSS N18 l=0.180u w=2.000u
M3 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M5 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M7 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M11 NET_53 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_53 VSS N18 l=0.180u w=2.000u
M13 VSS NET_75 NET_71 VSS N18 l=0.180u w=4.000u
M14 VSS NET_75 NET_71 VSS N18 l=0.180u w=4.000u
M15 NET_76 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_76 NET_77 NET_75 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_77 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_77 VSS N18 l=0.180u w=2.000u
M19 VSS NET_53 NET_47 VSS N18 l=0.180u w=2.000u
M20 VSS NET_53 NET_47 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_85 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_85 VDD P18 l=0.180u w=5.000u
M23 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M25 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M27 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M29 NET_5938 OEN NET_53 VDD P18 l=0.180u w=5.000u
M30 NET_5938 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_53 NET_47 VDD P18 l=0.180u w=5.000u
M32 VDD NET_53 NET_47 VDD P18 l=0.180u w=5.000u
M33 NET_47 NET_53 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_53 NET_47 VDD P18 l=0.180u w=5.000u
M35 NET_75 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_75 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_77 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_77 VDD P18 l=0.180u w=5.000u
M39 VDD NET_75 NET_71 VDD P18 l=0.180u w=5.000u
M40 VDD NET_75 NET_71 VDD P18 l=0.180u w=5.000u
M41 VDD NET_77 NET_75 VDD P18 l=0.180u w=5.000u
M42 NET_75 NET_77 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_94 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_94 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_94 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_94 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_93 NET_47 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_46 NET_94 VSS N33 l=0.350u w=8.000u
M78 VSS NET_46 NET_94 VSS N33 l=0.350u w=8.000u
M79 NET_52 OEN VSS VSS N33 l=0.350u w=7.440u
M80 NET_52 OEN VSS VSS N33 l=0.350u w=7.440u
M81 VSS NET_77 NET_50 VSS N33 l=0.350u w=7.440u
M82 NET_50 NET_77 VSS VSS N33 l=0.350u w=7.440u
M83 NET_59 NET_60 VSS VSS N33 l=0.350u w=4.400u
M84 VSS NET_75 NET_60 VSS N33 l=0.350u w=5.330u
M85 VSS NET_75 NET_60 VSS N33 l=0.350u w=5.330u
M86 NET_60 NET_75 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_71 NET_61 VSS N33 l=0.350u w=5.330u
M88 NET_61 NET_71 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_71 NET_61 VSS N33 l=0.350u w=5.330u
M90 NET_69 NET_3502 NET_67 VSS N33 l=0.350u w=8.000u
M91 NET_69 NET_52 VSS VSS N33 l=0.350u w=8.000u
M92 NET_93 NET_47 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_53 NET_46 VSS N33 l=0.350u w=8.000u
M94 VSS NET_53 NET_46 VSS N33 l=0.350u w=8.000u
M95 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M97 NET_88 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M98 NET_84 NET_88 NET_97 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_88 VSS VSS N33 l=0.350u w=8.000u
M100 VDD33 NET_97 NET_84 VSS N33 l=0.350u w=0.820u
M101 NET_88 VDD33 VSS VSS N33 l=4.550u w=0.800u
M102 VSS NET_97 NET_107 VSS N33 l=0.350u w=2.000u
M103 VSS NET_97 NET_107 VSS N33 l=0.350u w=2.000u
M104 NET_5919 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M105 NET_5919 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M106 NET_5921 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M107 NET_5921 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M108 NET_1365 NET_1365 NET_1365 NET_1365 P33 l=1.070u w=5.000u
M109 VSS NET_97 NET_3549 VDD33 P33 l=0.300u w=5.100u
M110 VSS NET_97 NET_3549 VDD33 P33 l=0.300u w=5.100u
M111 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M112 PAD NET_67 NET_5912 NET_1365 P33 l=0.300u w=30.000u
M113 NET_5912 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M114 VDD33 NET_59 NET_5910 NET_1365 P33 l=0.300u w=30.000u
M115 NET_5910 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M116 PAD NET_67 NET_5917 NET_1365 P33 l=0.300u w=30.000u
M117 NET_5917 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M118 VDD33 NET_59 NET_5915 NET_1365 P33 l=0.300u w=30.000u
M119 NET_5915 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M120 NET_97 NET_88 NET_3549 VDD33 P33 l=0.300u w=5.000u
M121 NET_97 NET_88 NET_3549 VDD33 P33 l=0.300u w=5.000u
M122 NET_3549 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 NET_3549 NET_97 VSS VDD33 P33 l=0.300u w=5.100u
M124 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M125 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M126 NET_107 NET_97 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M128 PAD NET_67 NET_5908 NET_1365 P33 l=0.300u w=30.000u
M129 NET_5908 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M130 NET_5906 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M131 NET_5906 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M132 PAD NET_67 NET_5898 NET_1365 P33 l=0.300u w=30.000u
M133 PAD NET_67 NET_5913 NET_1365 P33 l=0.300u w=30.000u
M134 NET_5913 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M135 NET_5907 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M136 NET_5907 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M137 PAD NET_67 NET_5902 NET_1365 P33 l=0.300u w=30.000u
M138 VDD33 NET_46 NET_94 VDD33 P33 l=0.300u w=4.600u
M139 VDD33 NET_59 NET_5896 NET_1365 P33 l=0.300u w=30.000u
M140 NET_5896 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M141 NET_5888 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M142 NET_5888 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M143 VDD33 NET_59 NET_5900 NET_1365 P33 l=0.300u w=30.000u
M144 NET_5900 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M145 NET_5893 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M146 NET_5893 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M147 VDD33 VSS NET_3502 VDD33 P33 l=0.300u w=5.000u
M148 NET_46 NET_93 VDD33 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_46 NET_93 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_59 NET_5886 NET_1365 P33 l=0.300u w=30.000u
M151 NET_5886 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M152 PAD NET_67 NET_5884 NET_1365 P33 l=0.300u w=30.000u
M153 NET_5884 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M154 NET_5875 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M155 VDD33 NET_59 NET_5891 NET_1365 P33 l=0.300u w=30.000u
M156 NET_5891 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M157 PAD NET_67 NET_5889 NET_1365 P33 l=0.300u w=30.000u
M158 NET_5889 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M159 NET_5879 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M160 VDD33 NET_52 NET_50 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_50 NET_52 VDD33 P33 l=0.300u w=5.000u
M162 PAD NET_67 NET_5873 NET_1365 P33 l=0.300u w=30.000u
M163 NET_5873 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M164 PAD NET_67 NET_5877 NET_1365 P33 l=0.300u w=30.000u
M165 NET_5877 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M166 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M167 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M168 VDD33 PAD NET_1365 NET_1365 P33 l=0.350u w=5.000u
M169 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M171 NET_59 NET_60 VDD33 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_60 NET_61 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_61 NET_60 VDD33 P33 l=0.300u w=5.000u
M175 PAD VDD33 NET_67 NET_1365 P33 l=0.350u w=10.000u
M176 PAD VDD33 NET_1365 NET_1365 P33 l=0.350u w=15.000u
M177 NET_5898 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M178 NET_5875 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M179 NET_5902 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M180 NET_5879 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M181 VDD33 NET_45 NET_3549 VDD33 P33 l=0.300u w=5.000u
M182 NET_3549 NET_97 VSS VDD33 P33 l=0.300u w=5.100u
R1 PAD NET_45 300.135
.ends PBSDL24

.subckt PBSDL16   PAD I OEN C FP
M1 VSS NET_107 NET_85 VSS N18 l=0.180u w=2.000u
M2 VSS NET_107 NET_85 VSS N18 l=0.180u w=2.000u
M3 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M5 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M7 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M11 NET_53 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_53 VSS N18 l=0.180u w=2.000u
M13 VSS NET_75 NET_71 VSS N18 l=0.180u w=4.000u
M14 VSS NET_75 NET_71 VSS N18 l=0.180u w=4.000u
M15 NET_76 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_76 NET_77 NET_75 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_77 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_77 VSS N18 l=0.180u w=2.000u
M19 VSS NET_53 NET_47 VSS N18 l=0.180u w=2.000u
M20 VSS NET_53 NET_47 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_85 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_85 VDD P18 l=0.180u w=5.000u
M23 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M25 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M27 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M29 NET_5930 OEN NET_53 VDD P18 l=0.180u w=5.000u
M30 NET_5930 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_53 NET_47 VDD P18 l=0.180u w=5.000u
M32 VDD NET_53 NET_47 VDD P18 l=0.180u w=5.000u
M33 NET_47 NET_53 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_53 NET_47 VDD P18 l=0.180u w=5.000u
M35 NET_75 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_75 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_77 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_77 VDD P18 l=0.180u w=5.000u
M39 VDD NET_75 NET_71 VDD P18 l=0.180u w=5.000u
M40 VDD NET_75 NET_71 VDD P18 l=0.180u w=5.000u
M41 VDD NET_77 NET_75 VDD P18 l=0.180u w=5.000u
M42 NET_75 NET_77 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_94 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_94 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_93 NET_47 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_46 NET_94 VSS N33 l=0.350u w=8.000u
M78 VSS NET_46 NET_94 VSS N33 l=0.350u w=8.000u
M79 NET_52 OEN VSS VSS N33 l=0.350u w=7.440u
M80 NET_52 OEN VSS VSS N33 l=0.350u w=7.440u
M81 VSS NET_77 NET_50 VSS N33 l=0.350u w=7.440u
M82 NET_50 NET_77 VSS VSS N33 l=0.350u w=7.440u
M83 NET_59 NET_60 VSS VSS N33 l=0.350u w=3.400u
M84 VSS NET_75 NET_60 VSS N33 l=0.350u w=5.330u
M85 VSS NET_75 NET_60 VSS N33 l=0.350u w=5.330u
M86 NET_60 NET_75 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_71 NET_61 VSS N33 l=0.350u w=5.330u
M88 NET_61 NET_71 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_71 NET_61 VSS N33 l=0.350u w=5.330u
M90 NET_69 NET_3502 NET_67 VSS N33 l=0.350u w=8.000u
M91 NET_69 NET_52 VSS VSS N33 l=0.350u w=8.000u
M92 NET_93 NET_47 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_53 NET_46 VSS N33 l=0.350u w=8.000u
M94 VSS NET_53 NET_46 VSS N33 l=0.350u w=8.000u
M95 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M97 NET_88 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M98 NET_84 NET_88 NET_97 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_88 VSS VSS N33 l=0.350u w=8.000u
M100 VDD33 NET_97 NET_84 VSS N33 l=0.350u w=0.820u
M101 NET_88 VDD33 VSS VSS N33 l=4.550u w=0.800u
M102 VSS NET_97 NET_107 VSS N33 l=0.350u w=2.000u
M103 VSS NET_97 NET_107 VSS N33 l=0.350u w=2.000u
M104 NET_5911 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M105 NET_5911 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M106 NET_5913 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M107 NET_5913 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M108 NET_1365 NET_1365 NET_1365 NET_1365 P33 l=1.070u w=5.000u
M109 VSS NET_97 NET_3549 VDD33 P33 l=0.300u w=5.100u
M110 VSS NET_97 NET_3549 VDD33 P33 l=0.300u w=5.100u
M111 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M112 PAD NET_67 NET_5904 NET_1365 P33 l=0.300u w=30.000u
M113 NET_5904 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M114 VDD33 NET_3502 NET_5902 NET_1365 P33 l=0.300u w=30.000u
M115 NET_5902 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M116 PAD NET_67 NET_5909 NET_1365 P33 l=0.300u w=30.000u
M117 NET_5909 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M118 VDD33 NET_3502 NET_5907 NET_1365 P33 l=0.300u w=30.000u
M119 NET_5907 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M120 NET_97 NET_88 NET_3549 VDD33 P33 l=0.300u w=5.000u
M121 NET_97 NET_88 NET_3549 VDD33 P33 l=0.300u w=5.000u
M122 NET_3549 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 NET_3549 NET_97 VSS VDD33 P33 l=0.300u w=5.100u
M124 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M125 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M126 NET_107 NET_97 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M128 PAD NET_67 NET_5900 NET_1365 P33 l=0.300u w=30.000u
M129 NET_5900 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M130 NET_5898 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M131 NET_5898 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M132 PAD NET_67 NET_5890 NET_1365 P33 l=0.300u w=30.000u
M133 PAD NET_67 NET_5905 NET_1365 P33 l=0.300u w=30.000u
M134 NET_5905 NET_3502 VDD33 NET_1365 P33 l=0.300u w=30.000u
M135 NET_5899 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M136 NET_5899 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M137 PAD NET_67 NET_5894 NET_1365 P33 l=0.300u w=30.000u
M138 NET_94 NET_46 VDD33 VDD33 P33 l=0.300u w=3.600u
M139 VDD33 NET_59 NET_5888 NET_1365 P33 l=0.300u w=30.000u
M140 NET_5888 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M141 NET_5880 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M142 NET_5880 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M143 VDD33 NET_59 NET_5892 NET_1365 P33 l=0.300u w=30.000u
M144 NET_5892 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M145 NET_5885 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M146 NET_5885 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M147 VDD33 VSS NET_3502 VDD33 P33 l=0.300u w=5.000u
M148 NET_46 NET_93 VDD33 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_46 NET_93 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_59 NET_5878 NET_1365 P33 l=0.300u w=30.000u
M151 NET_5878 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M152 PAD NET_67 NET_5876 NET_1365 P33 l=0.300u w=30.000u
M153 NET_5876 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M154 NET_5867 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M155 VDD33 NET_59 NET_5883 NET_1365 P33 l=0.300u w=30.000u
M156 NET_5883 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M157 PAD NET_67 NET_5881 NET_1365 P33 l=0.300u w=30.000u
M158 NET_5881 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M159 NET_5871 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M160 VDD33 NET_52 NET_50 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_50 NET_52 VDD33 P33 l=0.300u w=5.000u
M162 PAD NET_67 NET_5865 NET_1365 P33 l=0.300u w=30.000u
M163 NET_5865 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M164 PAD NET_67 NET_5869 NET_1365 P33 l=0.300u w=30.000u
M165 NET_5869 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M166 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M167 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M168 VDD33 PAD NET_1365 NET_1365 P33 l=0.350u w=5.000u
M169 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M171 NET_59 NET_60 VDD33 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_60 NET_61 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_61 NET_60 VDD33 P33 l=0.300u w=5.000u
M175 PAD VDD33 NET_67 NET_1365 P33 l=0.350u w=10.000u
M176 PAD VDD33 NET_1365 NET_1365 P33 l=0.350u w=15.000u
M177 NET_5890 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M178 NET_5867 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M179 NET_5894 NET_59 VDD33 NET_1365 P33 l=0.300u w=30.000u
M180 NET_5871 NET_67 PAD NET_1365 P33 l=0.300u w=30.000u
M181 VDD33 NET_45 NET_3549 VDD33 P33 l=0.300u w=5.000u
M182 NET_3549 NET_97 VSS VDD33 P33 l=0.300u w=5.100u
R1 PAD NET_45 300.135
.ends PBSDL16

.subckt PBSDL12   PAD I OEN C FP
M1 VSS NET_107 NET_85 VSS N18 l=0.180u w=2.000u
M2 VSS NET_107 NET_85 VSS N18 l=0.180u w=2.000u
M3 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M5 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M7 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_51 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_51 VSS N18 l=0.180u w=2.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_51 VSS N18 l=0.180u w=2.000u
M13 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M14 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M15 NET_75 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_75 NET_76 NET_74 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_51 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_51 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_85 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_85 VDD P18 l=0.180u w=5.000u
M23 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M25 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M26 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M27 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M29 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M30 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M33 NET_5963 OEN NET_51 VDD P18 l=0.180u w=5.000u
M34 NET_5963 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_10 NET_51 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M37 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M38 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M39 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_76 NET_74 VDD P18 l=0.180u w=5.000u
M42 NET_74 NET_76 VDD VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_94 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_94 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M60 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M64 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M66 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_45 NET_94 VSS N33 l=0.350u w=8.000u
M77 VSS NET_45 NET_94 VSS N33 l=0.350u w=8.000u
M78 NET_50 OEN VSS VSS N33 l=0.350u w=7.440u
M79 NET_50 OEN VSS VSS N33 l=0.350u w=7.440u
M80 VSS NET_76 NET_48 VSS N33 l=0.350u w=7.440u
M81 NET_48 NET_76 VSS VSS N33 l=0.350u w=7.440u
M82 VSS NET_59 NET_56 VSS N33 l=0.350u w=5.000u
M83 VSS NET_59 NET_56 VSS N33 l=0.350u w=5.000u
M84 VSS NET_74 NET_59 VSS N33 l=0.350u w=5.330u
M85 VSS NET_74 NET_59 VSS N33 l=0.350u w=5.330u
M86 NET_59 NET_74 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_70 NET_60 VSS N33 l=0.350u w=5.330u
M88 NET_60 NET_70 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_70 NET_60 VSS N33 l=0.350u w=5.330u
M90 NET_68 NET_3503 NET_66 VSS N33 l=0.350u w=8.000u
M91 NET_68 NET_50 VSS VSS N33 l=0.350u w=8.000u
M92 NET_93 NET_10 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_51 NET_45 VSS N33 l=0.350u w=8.000u
M94 VSS NET_51 NET_45 VSS N33 l=0.350u w=8.000u
M95 NET_93 NET_10 VSS VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M98 NET_88 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_88 NET_97 VSS N33 l=0.350u w=8.000u
M100 NET_84 NET_88 VSS VSS N33 l=0.350u w=8.000u
M101 VDD33 NET_97 NET_84 VSS N33 l=0.350u w=0.820u
M102 NET_88 VDD33 VSS VSS N33 l=4.550u w=0.800u
M103 VSS NET_97 NET_107 VSS N33 l=0.350u w=2.000u
M104 VSS NET_97 NET_107 VSS N33 l=0.350u w=2.000u
M105 NET_5944 NET_3503 VDD33 NET_1366 P33 l=0.300u w=30.000u
M106 NET_5944 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M107 NET_5946 NET_3503 VDD33 NET_1366 P33 l=0.300u w=30.000u
M108 NET_5946 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M109 NET_1366 NET_1366 NET_1366 NET_1366 P33 l=1.070u w=5.000u
M110 VSS NET_97 NET_3553 VDD33 P33 l=0.300u w=5.100u
M111 VSS NET_97 NET_3553 VDD33 P33 l=0.300u w=5.100u
M112 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M113 PAD NET_66 NET_5937 NET_1366 P33 l=0.300u w=30.000u
M114 NET_5937 NET_3503 VDD33 NET_1366 P33 l=0.300u w=30.000u
M115 VDD33 NET_3503 NET_5935 NET_1366 P33 l=0.300u w=30.000u
M116 NET_5935 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M117 PAD NET_66 NET_5942 NET_1366 P33 l=0.300u w=30.000u
M118 NET_5942 NET_3503 VDD33 NET_1366 P33 l=0.300u w=30.000u
M119 VDD33 NET_3503 NET_5940 NET_1366 P33 l=0.300u w=30.000u
M120 NET_5940 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M121 NET_97 NET_88 NET_3553 VDD33 P33 l=0.300u w=5.000u
M122 NET_97 NET_88 NET_3553 VDD33 P33 l=0.300u w=5.000u
M123 NET_3553 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 NET_3553 NET_97 VSS VDD33 P33 l=0.300u w=5.100u
M125 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M126 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M127 NET_107 NET_97 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_97 NET_107 VDD P33 l=0.300u w=5.000u
M129 PAD NET_66 NET_5933 NET_1366 P33 l=0.300u w=30.000u
M130 PAD NET_66 NET_5938 NET_1366 P33 l=0.300u w=30.000u
M131 NET_5931 NET_3503 VDD33 NET_1366 P33 l=0.300u w=30.000u
M132 NET_5931 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M133 PAD NET_66 NET_5923 NET_1366 P33 l=0.300u w=30.000u
M134 NET_5932 NET_3503 VDD33 NET_1366 P33 l=0.300u w=30.000u
M135 NET_5932 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M136 PAD NET_66 NET_5927 NET_1366 P33 l=0.300u w=30.000u
M137 VDD33 NET_45 NET_94 VDD33 P33 l=0.300u w=4.800u
M138 VDD33 NET_45 NET_94 VDD33 P33 l=0.300u w=4.800u
M139 NET_5933 NET_3503 VDD33 NET_1366 P33 l=0.300u w=30.000u
M140 NET_5938 NET_3503 VDD33 NET_1366 P33 l=0.300u w=30.000u
M141 VDD33 NET_56 NET_5921 NET_1366 P33 l=0.300u w=30.000u
M142 NET_5921 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M143 VDD33 NET_56 NET_5925 NET_1366 P33 l=0.300u w=30.000u
M144 NET_5925 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M145 NET_5913 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M146 NET_5913 NET_56 VDD33 NET_1366 P33 l=0.300u w=30.000u
M147 NET_5918 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M148 NET_5918 NET_56 VDD33 NET_1366 P33 l=0.300u w=30.000u
M149 VDD33 VSS NET_3503 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_45 NET_93 VDD33 P33 l=0.300u w=5.000u
M151 NET_45 NET_93 VDD33 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_56 NET_5911 NET_1366 P33 l=0.300u w=30.000u
M153 NET_5911 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M154 PAD NET_66 NET_5909 NET_1366 P33 l=0.300u w=30.000u
M155 VDD33 NET_56 NET_5916 NET_1366 P33 l=0.300u w=30.000u
M156 NET_5916 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M157 PAD NET_66 NET_5914 NET_1366 P33 l=0.300u w=30.000u
M158 VDD33 NET_50 NET_48 VDD33 P33 l=0.300u w=5.000u
M159 VDD33 NET_48 NET_50 VDD33 P33 l=0.300u w=5.000u
M160 NET_5900 NET_56 VDD33 NET_1366 P33 l=0.300u w=30.000u
M161 NET_5904 NET_56 VDD33 NET_1366 P33 l=0.300u w=30.000u
M162 NET_5909 NET_56 VDD33 NET_1366 P33 l=0.300u w=30.000u
M163 NET_5914 NET_56 VDD33 NET_1366 P33 l=0.300u w=30.000u
M164 PAD NET_66 NET_5898 NET_1366 P33 l=0.300u w=30.000u
M165 NET_5898 NET_56 VDD33 NET_1366 P33 l=0.300u w=30.000u
M166 PAD NET_66 NET_5902 NET_1366 P33 l=0.300u w=30.000u
M167 NET_5902 NET_56 VDD33 NET_1366 P33 l=0.300u w=30.000u
M168 NET_1366 PAD VDD33 NET_1366 P33 l=0.350u w=5.000u
M169 NET_1366 PAD VDD33 NET_1366 P33 l=0.350u w=5.000u
M170 VDD33 PAD NET_1366 NET_1366 P33 l=0.350u w=5.000u
M171 VDD33 NET_59 NET_56 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_59 NET_56 VDD33 P33 l=0.300u w=5.000u
M173 NET_56 NET_59 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_59 NET_56 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_59 NET_60 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_44 NET_3553 VDD33 P33 l=0.300u w=5.000u
M178 NET_3553 NET_97 VSS VDD33 P33 l=0.300u w=5.100u
M179 NET_5923 NET_3503 VDD33 NET_1366 P33 l=0.300u w=30.000u
M180 NET_5927 NET_3503 VDD33 NET_1366 P33 l=0.300u w=30.000u
M181 NET_5900 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M182 NET_5904 NET_66 PAD NET_1366 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_66 NET_1366 P33 l=0.350u w=10.000u
M184 PAD VDD33 NET_1366 NET_1366 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBSDL12

.subckt PBSD8   PAD OEN I C FP
M1 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M3 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M5 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M8 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_45 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_45 VSS N18 l=0.180u w=2.000u
M11 NET_45 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_45 VSS N18 l=0.180u w=2.000u
M13 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M14 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M15 NET_75 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_75 NET_76 NET_74 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_45 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_45 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_45 NET_10 VDD P18 l=0.180u w=5.000u
M25 VDD NET_45 NET_10 VDD P18 l=0.180u w=5.000u
M26 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M27 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M29 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M30 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M33 NET_5987 OEN NET_45 VDD P18 l=0.180u w=5.000u
M34 NET_5987 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_10 NET_45 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_45 NET_10 VDD P18 l=0.180u w=5.000u
M37 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M38 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M39 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_76 NET_74 VDD P18 l=0.180u w=5.000u
M42 NET_74 NET_76 VDD VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M60 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M64 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M66 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_69 NET_91 VSS N33 l=0.350u w=8.000u
M77 VSS NET_69 NET_91 VSS N33 l=0.350u w=8.000u
M78 VSS NET_53 NET_50 VSS N33 l=0.350u w=10.000u
M79 VSS NET_53 NET_50 VSS N33 l=0.350u w=10.000u
M80 VSS NET_74 NET_53 VSS N33 l=0.350u w=5.330u
M81 VSS NET_74 NET_53 VSS N33 l=0.350u w=5.330u
M82 NET_53 NET_74 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_70 NET_54 VSS N33 l=0.350u w=5.330u
M84 NET_54 NET_70 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_70 NET_54 VSS N33 l=0.350u w=5.330u
M86 NET_64 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_64 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_76 NET_62 VSS N33 l=0.350u w=7.440u
M89 NET_62 NET_76 VSS VSS N33 l=0.350u w=7.440u
M90 NET_67 NET_3507 NET_65 VSS N33 l=0.350u w=8.000u
M91 NET_67 NET_64 VSS VSS N33 l=0.350u w=8.000u
M92 NET_90 NET_10 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_45 NET_69 VSS N33 l=0.350u w=8.000u
M94 NET_69 NET_45 VSS VSS N33 l=0.350u w=8.000u
M95 NET_90 NET_10 VSS VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_85 VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_85 VSS N33 l=0.350u w=8.000u
M98 NET_85 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_85 NET_94 VSS N33 l=0.350u w=8.000u
M100 NET_84 NET_85 VSS VSS N33 l=0.350u w=8.000u
M101 VDD33 NET_94 NET_84 VSS N33 l=0.350u w=0.820u
M102 NET_85 VDD33 VSS VSS N33 l=4.550u w=0.800u
M103 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M104 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M105 NET_5968 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M106 NET_5968 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M107 NET_5970 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M108 NET_5970 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M109 NET_1366 NET_1366 NET_1366 NET_1366 P33 l=1.070u w=5.000u
M110 VSS NET_94 NET_3549 VDD33 P33 l=0.300u w=5.100u
M111 VSS NET_94 NET_3549 VDD33 P33 l=0.300u w=5.100u
M112 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M113 PAD NET_65 NET_5961 NET_1366 P33 l=0.300u w=30.000u
M114 NET_5961 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M115 VDD33 NET_3507 NET_5959 NET_1366 P33 l=0.300u w=30.000u
M116 NET_5959 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M117 PAD NET_65 NET_5966 NET_1366 P33 l=0.300u w=30.000u
M118 NET_5966 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M119 VDD33 NET_3507 NET_5964 NET_1366 P33 l=0.300u w=30.000u
M120 NET_5964 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M121 NET_94 NET_85 NET_3549 VDD33 P33 l=0.300u w=5.000u
M122 NET_94 NET_85 NET_3549 VDD33 P33 l=0.300u w=5.000u
M123 NET_3549 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 NET_3549 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M125 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M126 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M127 NET_107 NET_94 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M129 PAD NET_65 NET_5957 NET_1366 P33 l=0.300u w=30.000u
M130 PAD NET_65 NET_5962 NET_1366 P33 l=0.300u w=30.000u
M131 NET_5955 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M132 NET_5955 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M133 PAD NET_65 NET_5947 NET_1366 P33 l=0.300u w=30.000u
M134 NET_5956 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M135 NET_5956 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M136 PAD NET_65 NET_5951 NET_1366 P33 l=0.300u w=30.000u
M137 NET_91 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_91 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 NET_5957 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M140 NET_5962 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M141 VDD33 NET_3507 NET_5945 NET_1366 P33 l=0.300u w=30.000u
M142 NET_5945 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M143 VDD33 NET_3507 NET_5949 NET_1366 P33 l=0.300u w=30.000u
M144 NET_5949 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M145 VDD33 NET_69 NET_91 VDD33 P33 l=0.300u w=5.000u
M146 NET_91 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M147 NET_5937 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M148 NET_5937 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M149 NET_5942 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M150 NET_5942 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M151 VDD33 VSS NET_3507 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_69 NET_90 VDD33 P33 l=0.300u w=5.000u
M153 NET_69 NET_90 VDD33 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_50 NET_5935 NET_1366 P33 l=0.300u w=30.000u
M155 NET_5935 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M156 PAD NET_65 NET_5933 NET_1366 P33 l=0.300u w=30.000u
M157 VDD33 NET_50 NET_5940 NET_1366 P33 l=0.300u w=30.000u
M158 NET_5940 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M159 PAD NET_65 NET_5938 NET_1366 P33 l=0.300u w=30.000u
M160 VDD33 NET_64 NET_62 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_62 NET_64 VDD33 P33 l=0.300u w=5.000u
M162 NET_5924 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M163 NET_5928 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M164 NET_5933 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M165 NET_5938 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M166 PAD NET_65 NET_5922 NET_1366 P33 l=0.300u w=30.000u
M167 NET_5922 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M168 PAD NET_65 NET_5926 NET_1366 P33 l=0.300u w=30.000u
M169 NET_5926 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M170 NET_1366 PAD VDD33 NET_1366 P33 l=0.350u w=5.000u
M171 NET_1366 PAD VDD33 NET_1366 P33 l=0.350u w=5.000u
M172 VDD33 PAD NET_1366 NET_1366 P33 l=0.350u w=5.000u
M173 NET_50 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 NET_50 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_53 NET_50 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_53 NET_54 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_54 NET_53 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_44 NET_3549 VDD33 P33 l=0.300u w=5.000u
M179 NET_3549 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M180 NET_5947 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M181 NET_5951 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M182 NET_5924 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M183 NET_5928 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_65 NET_1366 P33 l=0.350u w=10.000u
M185 PAD VDD33 NET_1366 NET_1366 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBSD8

.subckt PBSD4   PAD OEN I C FP
M1 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M3 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M5 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M8 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M22 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M23 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M25 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M27 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M29 NET_5972 OEN NET_74 VDD P18 l=0.180u w=5.000u
M30 NET_5972 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M32 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M33 NET_10 NET_74 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M35 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M39 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M40 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M41 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M42 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_88 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_88 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M60 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M64 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M66 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_88 NET_64 VSS VSS N33 l=0.350u w=4.000u
M77 NET_88 NET_64 VSS VSS N33 l=0.350u w=4.000u
M78 VSS NET_64 NET_88 VSS N33 l=0.350u w=4.000u
M79 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M80 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M81 VSS NET_69 NET_48 VSS N33 l=0.350u w=5.330u
M82 VSS NET_69 NET_48 VSS N33 l=0.350u w=5.330u
M83 NET_48 NET_69 VSS VSS N33 l=0.350u w=5.330u
M84 VSS NET_65 NET_49 VSS N33 l=0.350u w=5.330u
M85 NET_49 NET_65 VSS VSS N33 l=0.350u w=5.330u
M86 VSS NET_65 NET_49 VSS N33 l=0.350u w=5.330u
M87 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M88 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M89 VSS NET_71 NET_57 VSS N33 l=0.350u w=7.440u
M90 NET_57 NET_71 VSS VSS N33 l=0.350u w=7.440u
M91 NET_62 NET_3517 NET_60 VSS N33 l=0.350u w=8.000u
M92 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M93 NET_86 NET_10 VSS VSS N33 l=0.350u w=8.000u
M94 VSS NET_74 NET_64 VSS N33 l=0.350u w=8.000u
M95 NET_64 NET_74 VSS VSS N33 l=0.350u w=8.000u
M96 NET_86 NET_10 VSS VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M98 NET_44 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M99 NET_91 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M100 NET_84 NET_91 NET_95 VSS N33 l=0.350u w=8.000u
M101 NET_84 NET_91 VSS VSS N33 l=0.350u w=8.000u
M102 VDD33 NET_95 NET_84 VSS N33 l=0.350u w=0.820u
M103 NET_91 VDD33 VSS VSS N33 l=4.550u w=0.800u
M104 VSS NET_95 NET_108 VSS N33 l=0.350u w=2.000u
M105 VSS NET_95 NET_108 VSS N33 l=0.350u w=2.000u
M106 NET_5953 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M107 NET_5953 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M108 NET_5955 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M109 NET_5955 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M110 NET_1367 NET_1367 NET_1367 NET_1367 P33 l=1.070u w=5.000u
M111 VSS NET_95 NET_3558 VDD33 P33 l=0.300u w=5.100u
M112 VSS NET_95 NET_3558 VDD33 P33 l=0.300u w=5.100u
M113 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M114 PAD NET_60 NET_5946 NET_1367 P33 l=0.300u w=30.000u
M115 NET_5946 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M116 VDD33 NET_3517 NET_5944 NET_1367 P33 l=0.300u w=30.000u
M117 NET_5944 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M118 PAD NET_60 NET_5951 NET_1367 P33 l=0.300u w=30.000u
M119 NET_5951 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M120 VDD33 NET_3517 NET_5949 NET_1367 P33 l=0.300u w=30.000u
M121 NET_5949 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M122 NET_95 NET_91 NET_3558 VDD33 P33 l=0.300u w=5.000u
M123 NET_95 NET_91 NET_3558 VDD33 P33 l=0.300u w=5.000u
M124 NET_3558 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 NET_3558 NET_95 VSS VDD33 P33 l=0.300u w=5.100u
M126 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M127 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M128 NET_108 NET_95 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M130 PAD NET_60 NET_5942 NET_1367 P33 l=0.300u w=30.000u
M131 NET_5942 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M132 NET_5940 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M133 NET_5940 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M134 PAD NET_60 NET_5932 NET_1367 P33 l=0.300u w=30.000u
M135 PAD NET_60 NET_5947 NET_1367 P33 l=0.300u w=30.000u
M136 NET_5947 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M137 NET_5941 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M138 NET_5941 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M139 PAD NET_60 NET_5936 NET_1367 P33 l=0.300u w=30.000u
M140 NET_88 NET_64 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 NET_88 NET_64 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_3517 NET_5930 NET_1367 P33 l=0.300u w=30.000u
M143 NET_5930 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M144 NET_5922 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M145 NET_5922 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M146 VDD33 NET_3517 NET_5934 NET_1367 P33 l=0.300u w=30.000u
M147 NET_5934 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M148 NET_5927 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M149 NET_5927 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M150 VDD33 VSS NET_3517 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_64 NET_88 VDD33 P33 l=0.300u w=5.000u
M152 NET_64 NET_86 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_64 NET_86 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_3517 NET_5920 NET_1367 P33 l=0.300u w=30.000u
M155 NET_5920 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M156 PAD NET_60 NET_5918 NET_1367 P33 l=0.300u w=30.000u
M157 NET_5918 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M158 NET_5909 NET_45 VDD33 NET_1367 P33 l=0.300u w=30.000u
M159 VDD33 NET_3517 NET_5925 NET_1367 P33 l=0.300u w=30.000u
M160 NET_5925 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M161 PAD NET_60 NET_5923 NET_1367 P33 l=0.300u w=30.000u
M162 NET_5923 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M163 NET_5913 NET_45 VDD33 NET_1367 P33 l=0.300u w=30.000u
M164 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M166 PAD NET_60 NET_5907 NET_1367 P33 l=0.300u w=30.000u
M167 NET_5907 NET_45 VDD33 NET_1367 P33 l=0.300u w=30.000u
M168 PAD NET_60 NET_5911 NET_1367 P33 l=0.300u w=30.000u
M169 NET_5911 NET_45 VDD33 NET_1367 P33 l=0.300u w=30.000u
M170 NET_1367 PAD VDD33 NET_1367 P33 l=0.350u w=5.000u
M171 NET_1367 PAD VDD33 NET_1367 P33 l=0.350u w=5.000u
M172 VDD33 PAD NET_1367 NET_1367 P33 l=0.350u w=5.000u
M173 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M177 NET_5932 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M178 NET_5909 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M179 NET_5936 NET_3517 VDD33 NET_1367 P33 l=0.300u w=30.000u
M180 NET_5913 NET_60 PAD NET_1367 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_1367 NET_1367 P33 l=0.350u w=15.000u
M182 PAD VDD33 NET_60 NET_1367 P33 l=0.350u w=10.000u
M183 VDD33 NET_44 NET_3558 VDD33 P33 l=0.300u w=5.000u
M184 NET_3558 NET_95 VSS VDD33 P33 l=0.300u w=5.100u
R1 PAD NET_44 300.135
.ends PBSD4

.subckt PBSD24   PAD I OEN C FP
M1 VSS NET_108 NET_85 VSS N18 l=0.180u w=2.000u
M2 VSS NET_108 NET_85 VSS N18 l=0.180u w=2.000u
M3 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M5 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M7 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_50 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_50 VSS N18 l=0.180u w=2.000u
M11 NET_50 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_50 VSS N18 l=0.180u w=2.000u
M13 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M14 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M15 NET_75 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_75 NET_76 NET_74 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_50 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_50 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_108 NET_85 VDD P18 l=0.180u w=5.000u
M22 VDD NET_108 NET_85 VDD P18 l=0.180u w=5.000u
M23 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_50 NET_10 VDD P18 l=0.180u w=5.000u
M25 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M26 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M27 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M28 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M29 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M32 NET_5986 OEN NET_50 VDD P18 l=0.180u w=5.000u
M33 NET_5986 I VDD VDD P18 l=0.180u w=5.000u
M34 NET_10 NET_50 VDD VDD P18 l=0.180u w=5.000u
M35 VDD NET_50 NET_10 VDD P18 l=0.180u w=5.000u
M36 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M37 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M38 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_76 NET_74 VDD P18 l=0.180u w=5.000u
M41 NET_74 NET_76 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_50 NET_10 VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_95 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_95 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_95 NET_25 VSSD N33 l=0.400u w=28.000u
M60 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_95 NET_14 VSSD N33 l=0.400u w=28.000u
M64 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M66 NET_12 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_95 NET_69 VSS VSS N33 l=0.350u w=8.000u
M77 NET_95 NET_69 VSS VSS N33 l=0.350u w=8.000u
M78 VSS NET_69 NET_95 VSS N33 l=0.350u w=8.000u
M79 NET_49 OEN VSS VSS N33 l=0.350u w=7.440u
M80 NET_49 OEN VSS VSS N33 l=0.350u w=7.440u
M81 VSS NET_76 NET_47 VSS N33 l=0.350u w=7.440u
M82 NET_47 NET_76 VSS VSS N33 l=0.350u w=7.440u
M83 VSS NET_58 NET_55 VSS N33 l=0.350u w=8.000u
M84 VSS NET_58 NET_55 VSS N33 l=0.350u w=8.000u
M85 VSS NET_74 NET_58 VSS N33 l=0.350u w=5.330u
M86 VSS NET_74 NET_58 VSS N33 l=0.350u w=5.330u
M87 NET_58 NET_74 VSS VSS N33 l=0.350u w=5.330u
M88 VSS NET_70 NET_59 VSS N33 l=0.350u w=5.330u
M89 NET_59 NET_70 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_70 NET_59 VSS N33 l=0.350u w=5.330u
M91 NET_67 NET_3505 NET_65 VSS N33 l=0.350u w=8.000u
M92 NET_67 NET_49 VSS VSS N33 l=0.350u w=8.000u
M93 NET_93 NET_10 VSS VSS N33 l=0.350u w=8.000u
M94 VSS NET_50 NET_69 VSS N33 l=0.350u w=8.000u
M95 NET_69 NET_50 VSS VSS N33 l=0.350u w=8.000u
M96 NET_93 NET_10 VSS VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M98 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M99 NET_88 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M100 NET_84 NET_88 NET_98 VSS N33 l=0.350u w=8.000u
M101 NET_84 NET_88 VSS VSS N33 l=0.350u w=8.000u
M102 VDD33 NET_98 NET_84 VSS N33 l=0.350u w=0.820u
M103 NET_88 VDD33 VSS VSS N33 l=4.550u w=0.800u
M104 VSS NET_98 NET_108 VSS N33 l=0.350u w=2.000u
M105 VSS NET_98 NET_108 VSS N33 l=0.350u w=2.000u
M106 NET_5967 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M107 NET_5967 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M108 NET_5969 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M109 NET_5969 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M110 NET_1367 NET_1367 NET_1367 NET_1367 P33 l=1.070u w=5.000u
M111 VSS NET_98 NET_3546 VDD33 P33 l=0.300u w=5.100u
M112 VSS NET_98 NET_3546 VDD33 P33 l=0.300u w=5.100u
M113 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M114 PAD NET_65 NET_5960 NET_1367 P33 l=0.300u w=30.000u
M115 NET_5960 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M116 VDD33 NET_55 NET_5958 NET_1367 P33 l=0.300u w=30.000u
M117 NET_5958 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M118 PAD NET_65 NET_5965 NET_1367 P33 l=0.300u w=30.000u
M119 NET_5965 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M120 VDD33 NET_55 NET_5963 NET_1367 P33 l=0.300u w=30.000u
M121 NET_5963 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M122 NET_98 NET_88 NET_3546 VDD33 P33 l=0.300u w=5.000u
M123 NET_98 NET_88 NET_3546 VDD33 P33 l=0.300u w=5.000u
M124 NET_3546 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 NET_3546 NET_98 VSS VDD33 P33 l=0.300u w=5.100u
M126 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M127 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M128 NET_108 NET_98 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M130 PAD NET_65 NET_5956 NET_1367 P33 l=0.300u w=30.000u
M131 PAD NET_65 NET_5961 NET_1367 P33 l=0.300u w=30.000u
M132 NET_5954 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M133 NET_5954 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M134 PAD NET_65 NET_5946 NET_1367 P33 l=0.300u w=30.000u
M135 NET_5955 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M136 NET_5955 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M137 PAD NET_65 NET_5950 NET_1367 P33 l=0.300u w=30.000u
M138 NET_95 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 NET_95 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M140 NET_5956 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M141 NET_5961 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M142 VDD33 NET_55 NET_5944 NET_1367 P33 l=0.300u w=30.000u
M143 NET_5944 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M144 VDD33 NET_55 NET_5948 NET_1367 P33 l=0.300u w=30.000u
M145 NET_5948 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M146 VDD33 NET_69 NET_95 VDD33 P33 l=0.300u w=5.000u
M147 NET_5936 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M148 NET_5936 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M149 NET_5941 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M150 NET_5941 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M151 VDD33 VSS NET_3505 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_69 NET_93 VDD33 P33 l=0.300u w=5.000u
M153 NET_69 NET_93 VDD33 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_55 NET_5934 NET_1367 P33 l=0.300u w=30.000u
M155 NET_5934 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M156 PAD NET_65 NET_5932 NET_1367 P33 l=0.300u w=30.000u
M157 VDD33 NET_55 NET_5939 NET_1367 P33 l=0.300u w=30.000u
M158 NET_5939 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M159 PAD NET_65 NET_5937 NET_1367 P33 l=0.300u w=30.000u
M160 VDD33 NET_49 NET_47 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_47 NET_49 VDD33 P33 l=0.300u w=5.000u
M162 NET_5923 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M163 NET_5927 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M164 NET_5932 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M165 NET_5937 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M166 PAD NET_65 NET_5921 NET_1367 P33 l=0.300u w=30.000u
M167 NET_5921 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M168 PAD NET_65 NET_5925 NET_1367 P33 l=0.300u w=30.000u
M169 NET_5925 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M170 NET_1367 PAD VDD33 NET_1367 P33 l=0.350u w=5.000u
M171 NET_1367 PAD VDD33 NET_1367 P33 l=0.350u w=5.000u
M172 VDD33 PAD NET_1367 NET_1367 P33 l=0.350u w=5.000u
M173 NET_55 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 NET_55 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_58 NET_55 VDD33 P33 l=0.300u w=5.000u
M176 NET_55 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_58 NET_55 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_58 NET_59 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_59 NET_58 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_44 NET_3546 VDD33 P33 l=0.300u w=5.000u
M181 NET_3546 NET_98 VSS VDD33 P33 l=0.300u w=5.100u
M182 NET_5946 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M183 NET_5950 NET_55 VDD33 NET_1367 P33 l=0.300u w=30.000u
M184 NET_5923 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M185 NET_5927 NET_65 PAD NET_1367 P33 l=0.300u w=30.000u
M186 PAD VDD33 NET_65 NET_1367 P33 l=0.350u w=10.000u
M187 PAD VDD33 NET_1367 NET_1367 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBSD24

.subckt PBSD2   PAD OEN I C FP
M1 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M3 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M5 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M8 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M25 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M27 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M29 NET_5961 OEN NET_74 VDD P18 l=0.180u w=5.000u
M30 NET_5961 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M32 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M33 NET_10 NET_74 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M35 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M39 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M40 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M41 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M42 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M60 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M64 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M66 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_45 NET_87 VSS N33 l=0.350u w=4.000u
M77 VSS NET_45 NET_87 VSS N33 l=0.350u w=4.000u
M78 VSS NET_49 NET_46 VSS N33 l=0.350u w=4.000u
M79 VSS NET_49 NET_46 VSS N33 l=0.350u w=4.000u
M80 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M81 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M82 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M84 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M86 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M89 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M90 NET_63 NET_3512 NET_61 VSS N33 l=0.350u w=8.000u
M91 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M92 NET_86 NET_10 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M94 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M95 NET_86 NET_10 VSS VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M98 NET_90 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_90 NET_94 VSS N33 l=0.350u w=8.000u
M100 NET_84 NET_90 VSS VSS N33 l=0.350u w=8.000u
M101 VDD33 NET_94 NET_84 VSS N33 l=0.350u w=0.820u
M102 NET_90 VDD33 VSS VSS N33 l=4.550u w=0.800u
M103 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M104 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M105 VSS NET_94 NET_3566 VDD33 P33 l=0.300u w=5.100u
M106 VSS NET_94 NET_3566 VDD33 P33 l=0.300u w=5.100u
M107 NET_5942 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M108 NET_5942 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M109 NET_5944 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M110 NET_5944 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M111 NET_1366 NET_1366 NET_1366 NET_1366 P33 l=1.070u w=5.000u
M112 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M113 NET_94 NET_90 NET_3566 VDD33 P33 l=0.300u w=5.000u
M114 NET_94 NET_90 NET_3566 VDD33 P33 l=0.300u w=5.000u
M115 NET_3566 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M116 NET_3566 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M117 PAD NET_61 NET_5935 NET_1366 P33 l=0.300u w=30.000u
M118 NET_5935 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M119 VDD33 NET_3512 NET_5933 NET_1366 P33 l=0.300u w=30.000u
M120 NET_5933 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M121 PAD NET_61 NET_5940 NET_1366 P33 l=0.300u w=30.000u
M122 NET_5940 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M123 VDD33 NET_3512 NET_5938 NET_1366 P33 l=0.300u w=30.000u
M124 NET_5938 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M125 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M126 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M127 NET_107 NET_94 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M129 VDD33 NET_45 NET_87 VDD33 P33 l=0.300u w=5.000u
M130 PAD NET_61 NET_5931 NET_1366 P33 l=0.300u w=30.000u
M131 NET_5931 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M132 NET_5929 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M133 NET_5929 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M134 PAD NET_61 NET_5921 NET_1366 P33 l=0.300u w=30.000u
M135 PAD NET_61 NET_5936 NET_1366 P33 l=0.300u w=30.000u
M136 NET_5936 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M137 NET_5930 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M138 NET_5930 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M139 PAD NET_61 NET_5925 NET_1366 P33 l=0.300u w=30.000u
M140 VDD33 VSS NET_3512 VDD33 P33 l=0.300u w=5.000u
M141 NET_45 NET_86 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_45 NET_86 VDD33 P33 l=0.300u w=5.000u
M143 VDD33 NET_3512 NET_5919 NET_1366 P33 l=0.300u w=30.000u
M144 NET_5919 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M145 NET_5911 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M146 NET_5911 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M147 VDD33 NET_3512 NET_5923 NET_1366 P33 l=0.300u w=30.000u
M148 NET_5923 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M149 NET_5916 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M150 NET_5916 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M151 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_3512 NET_5909 NET_1366 P33 l=0.300u w=30.000u
M154 NET_5909 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M155 PAD NET_61 NET_5907 NET_1366 P33 l=0.300u w=30.000u
M156 NET_5907 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M157 NET_5898 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M158 VDD33 NET_3512 NET_5914 NET_1366 P33 l=0.300u w=30.000u
M159 NET_5914 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M160 PAD NET_61 NET_5912 NET_1366 P33 l=0.300u w=30.000u
M161 NET_5912 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M162 NET_5902 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M163 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M165 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M166 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M168 PAD NET_61 NET_5896 NET_1366 P33 l=0.300u w=30.000u
M169 NET_5896 NET_46 VDD33 NET_1366 P33 l=0.300u w=30.000u
M170 PAD NET_61 NET_5900 NET_1366 P33 l=0.300u w=30.000u
M171 NET_5900 NET_46 VDD33 NET_1366 P33 l=0.300u w=30.000u
M172 NET_1366 PAD VDD33 NET_1366 P33 l=0.350u w=5.000u
M173 NET_1366 PAD VDD33 NET_1366 P33 l=0.350u w=5.000u
M174 VDD33 PAD NET_1366 NET_1366 P33 l=0.350u w=5.000u
M175 VDD33 NET_44 NET_3566 VDD33 P33 l=0.300u w=5.000u
M176 NET_3566 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M177 NET_5921 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M178 NET_5898 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M179 NET_5925 NET_3512 VDD33 NET_1366 P33 l=0.300u w=30.000u
M180 NET_5902 NET_61 PAD NET_1366 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_1366 NET_1366 P33 l=0.350u w=15.000u
M182 PAD VDD33 NET_61 NET_1366 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBSD2

.subckt PBSD16   PAD OEN I C FP
M1 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M3 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M5 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M8 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_45 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_45 VSS N18 l=0.180u w=2.000u
M11 NET_45 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_45 VSS N18 l=0.180u w=2.000u
M13 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M14 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M15 NET_75 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_75 NET_76 NET_74 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_45 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_45 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_45 NET_10 VDD P18 l=0.180u w=5.000u
M25 VDD NET_45 NET_10 VDD P18 l=0.180u w=5.000u
M26 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M27 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M29 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M30 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M33 NET_5987 OEN NET_45 VDD P18 l=0.180u w=5.000u
M34 NET_5987 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_10 NET_45 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_45 NET_10 VDD P18 l=0.180u w=5.000u
M37 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M38 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M39 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_76 NET_74 VDD P18 l=0.180u w=5.000u
M42 NET_74 NET_76 VDD VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_91 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_91 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M60 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M64 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M66 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_69 NET_91 VSS N33 l=0.350u w=8.000u
M77 VSS NET_69 NET_91 VSS N33 l=0.350u w=8.000u
M78 VSS NET_53 NET_50 VSS N33 l=0.350u w=10.000u
M79 VSS NET_53 NET_50 VSS N33 l=0.350u w=10.000u
M80 VSS NET_74 NET_53 VSS N33 l=0.350u w=5.330u
M81 VSS NET_74 NET_53 VSS N33 l=0.350u w=5.330u
M82 NET_53 NET_74 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_70 NET_54 VSS N33 l=0.350u w=5.330u
M84 NET_54 NET_70 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_70 NET_54 VSS N33 l=0.350u w=5.330u
M86 NET_64 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_64 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_76 NET_62 VSS N33 l=0.350u w=7.440u
M89 NET_62 NET_76 VSS VSS N33 l=0.350u w=7.440u
M90 NET_67 NET_3507 NET_65 VSS N33 l=0.350u w=8.000u
M91 NET_67 NET_64 VSS VSS N33 l=0.350u w=8.000u
M92 NET_90 NET_10 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_45 NET_69 VSS N33 l=0.350u w=8.000u
M94 NET_69 NET_45 VSS VSS N33 l=0.350u w=8.000u
M95 NET_90 NET_10 VSS VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_85 VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_85 VSS N33 l=0.350u w=8.000u
M98 NET_85 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_85 NET_94 VSS N33 l=0.350u w=8.000u
M100 NET_84 NET_85 VSS VSS N33 l=0.350u w=8.000u
M101 VDD33 NET_94 NET_84 VSS N33 l=0.350u w=0.820u
M102 NET_85 VDD33 VSS VSS N33 l=4.550u w=0.800u
M103 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M104 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M105 NET_5968 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M106 NET_5968 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M107 NET_5970 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M108 NET_5970 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M109 NET_1366 NET_1366 NET_1366 NET_1366 P33 l=1.070u w=5.000u
M110 VSS NET_94 NET_3549 VDD33 P33 l=0.300u w=5.100u
M111 VSS NET_94 NET_3549 VDD33 P33 l=0.300u w=5.100u
M112 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M113 PAD NET_65 NET_5961 NET_1366 P33 l=0.300u w=30.000u
M114 NET_5961 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M115 VDD33 NET_3507 NET_5959 NET_1366 P33 l=0.300u w=30.000u
M116 NET_5959 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M117 PAD NET_65 NET_5966 NET_1366 P33 l=0.300u w=30.000u
M118 NET_5966 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M119 VDD33 NET_3507 NET_5964 NET_1366 P33 l=0.300u w=30.000u
M120 NET_5964 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M121 NET_94 NET_85 NET_3549 VDD33 P33 l=0.300u w=5.000u
M122 NET_94 NET_85 NET_3549 VDD33 P33 l=0.300u w=5.000u
M123 NET_3549 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 NET_3549 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M125 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M126 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M127 NET_107 NET_94 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M129 PAD NET_65 NET_5957 NET_1366 P33 l=0.300u w=30.000u
M130 PAD NET_65 NET_5962 NET_1366 P33 l=0.300u w=30.000u
M131 NET_5955 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M132 NET_5955 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M133 PAD NET_65 NET_5947 NET_1366 P33 l=0.300u w=30.000u
M134 NET_5956 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M135 NET_5956 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M136 PAD NET_65 NET_5951 NET_1366 P33 l=0.300u w=30.000u
M137 NET_91 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_91 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 NET_5957 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M140 NET_5962 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M141 VDD33 NET_50 NET_5945 NET_1366 P33 l=0.300u w=30.000u
M142 NET_5945 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M143 VDD33 NET_50 NET_5949 NET_1366 P33 l=0.300u w=30.000u
M144 NET_5949 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M145 VDD33 NET_69 NET_91 VDD33 P33 l=0.300u w=5.000u
M146 NET_91 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M147 NET_5937 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M148 NET_5937 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M149 NET_5942 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M150 NET_5942 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M151 VDD33 VSS NET_3507 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_69 NET_90 VDD33 P33 l=0.300u w=5.000u
M153 NET_69 NET_90 VDD33 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_50 NET_5935 NET_1366 P33 l=0.300u w=30.000u
M155 NET_5935 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M156 PAD NET_65 NET_5933 NET_1366 P33 l=0.300u w=30.000u
M157 VDD33 NET_50 NET_5940 NET_1366 P33 l=0.300u w=30.000u
M158 NET_5940 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M159 PAD NET_65 NET_5938 NET_1366 P33 l=0.300u w=30.000u
M160 VDD33 NET_64 NET_62 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_62 NET_64 VDD33 P33 l=0.300u w=5.000u
M162 NET_5924 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M163 NET_5928 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M164 NET_5933 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M165 NET_5938 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M166 PAD NET_65 NET_5922 NET_1366 P33 l=0.300u w=30.000u
M167 NET_5922 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M168 PAD NET_65 NET_5926 NET_1366 P33 l=0.300u w=30.000u
M169 NET_5926 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M170 NET_1366 PAD VDD33 NET_1366 P33 l=0.350u w=5.000u
M171 NET_1366 PAD VDD33 NET_1366 P33 l=0.350u w=5.000u
M172 VDD33 PAD NET_1366 NET_1366 P33 l=0.350u w=5.000u
M173 NET_50 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 NET_50 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_53 NET_50 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_53 NET_54 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_54 NET_53 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_44 NET_3549 VDD33 P33 l=0.300u w=5.000u
M179 NET_3549 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M180 NET_5947 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M181 NET_5951 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M182 NET_5924 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M183 NET_5928 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_65 NET_1366 P33 l=0.350u w=10.000u
M185 PAD VDD33 NET_1366 NET_1366 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBSD16

.subckt PBSD12   PAD OEN I C FP
M1 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M3 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M5 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M8 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_45 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_45 VSS N18 l=0.180u w=2.000u
M11 NET_45 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_45 VSS N18 l=0.180u w=2.000u
M13 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M14 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M15 NET_75 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_75 NET_76 NET_74 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_45 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_45 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_45 NET_10 VDD P18 l=0.180u w=5.000u
M25 VDD NET_45 NET_10 VDD P18 l=0.180u w=5.000u
M26 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M27 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M29 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M30 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M33 NET_5987 OEN NET_45 VDD P18 l=0.180u w=5.000u
M34 NET_5987 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_10 NET_45 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_45 NET_10 VDD P18 l=0.180u w=5.000u
M37 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M38 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M39 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_76 NET_74 VDD P18 l=0.180u w=5.000u
M42 NET_74 NET_76 VDD VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_91 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_91 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_91 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M60 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M64 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M66 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_69 NET_91 VSS N33 l=0.350u w=8.000u
M77 VSS NET_69 NET_91 VSS N33 l=0.350u w=8.000u
M78 VSS NET_53 NET_50 VSS N33 l=0.350u w=10.000u
M79 VSS NET_53 NET_50 VSS N33 l=0.350u w=10.000u
M80 VSS NET_74 NET_53 VSS N33 l=0.350u w=5.330u
M81 VSS NET_74 NET_53 VSS N33 l=0.350u w=5.330u
M82 NET_53 NET_74 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_70 NET_54 VSS N33 l=0.350u w=5.330u
M84 NET_54 NET_70 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_70 NET_54 VSS N33 l=0.350u w=5.330u
M86 NET_64 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_64 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_76 NET_62 VSS N33 l=0.350u w=7.440u
M89 NET_62 NET_76 VSS VSS N33 l=0.350u w=7.440u
M90 NET_67 NET_3507 NET_65 VSS N33 l=0.350u w=8.000u
M91 NET_67 NET_64 VSS VSS N33 l=0.350u w=8.000u
M92 NET_90 NET_10 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_45 NET_69 VSS N33 l=0.350u w=8.000u
M94 NET_69 NET_45 VSS VSS N33 l=0.350u w=8.000u
M95 NET_90 NET_10 VSS VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_85 VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_85 VSS N33 l=0.350u w=8.000u
M98 NET_85 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_85 NET_94 VSS N33 l=0.350u w=8.000u
M100 NET_84 NET_85 VSS VSS N33 l=0.350u w=8.000u
M101 VDD33 NET_94 NET_84 VSS N33 l=0.350u w=0.820u
M102 NET_85 VDD33 VSS VSS N33 l=4.550u w=0.800u
M103 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M104 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M105 NET_5968 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M106 NET_5968 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M107 NET_5970 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M108 NET_5970 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M109 NET_1366 NET_1366 NET_1366 NET_1366 P33 l=1.070u w=5.000u
M110 VSS NET_94 NET_3549 VDD33 P33 l=0.300u w=5.100u
M111 VSS NET_94 NET_3549 VDD33 P33 l=0.300u w=5.100u
M112 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M113 PAD NET_65 NET_5961 NET_1366 P33 l=0.300u w=30.000u
M114 NET_5961 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M115 VDD33 NET_3507 NET_5959 NET_1366 P33 l=0.300u w=30.000u
M116 NET_5959 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M117 PAD NET_65 NET_5966 NET_1366 P33 l=0.300u w=30.000u
M118 NET_5966 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M119 VDD33 NET_3507 NET_5964 NET_1366 P33 l=0.300u w=30.000u
M120 NET_5964 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M121 NET_94 NET_85 NET_3549 VDD33 P33 l=0.300u w=5.000u
M122 NET_94 NET_85 NET_3549 VDD33 P33 l=0.300u w=5.000u
M123 NET_3549 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 NET_3549 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M125 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M126 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M127 NET_107 NET_94 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M129 PAD NET_65 NET_5957 NET_1366 P33 l=0.300u w=30.000u
M130 PAD NET_65 NET_5962 NET_1366 P33 l=0.300u w=30.000u
M131 NET_5955 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M132 NET_5955 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M133 PAD NET_65 NET_5947 NET_1366 P33 l=0.300u w=30.000u
M134 NET_5956 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M135 NET_5956 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M136 PAD NET_65 NET_5951 NET_1366 P33 l=0.300u w=30.000u
M137 NET_91 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_91 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 NET_5957 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M140 NET_5962 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M141 VDD33 NET_50 NET_5945 NET_1366 P33 l=0.300u w=30.000u
M142 NET_5945 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M143 VDD33 NET_50 NET_5949 NET_1366 P33 l=0.300u w=30.000u
M144 NET_5949 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M145 VDD33 NET_69 NET_91 VDD33 P33 l=0.300u w=5.000u
M146 NET_91 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M147 NET_5937 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M148 NET_5937 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M149 NET_5942 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M150 NET_5942 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M151 VDD33 VSS NET_3507 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_69 NET_90 VDD33 P33 l=0.300u w=5.000u
M153 NET_69 NET_90 VDD33 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_50 NET_5935 NET_1366 P33 l=0.300u w=30.000u
M155 NET_5935 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M156 PAD NET_65 NET_5933 NET_1366 P33 l=0.300u w=30.000u
M157 VDD33 NET_50 NET_5940 NET_1366 P33 l=0.300u w=30.000u
M158 NET_5940 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M159 PAD NET_65 NET_5938 NET_1366 P33 l=0.300u w=30.000u
M160 VDD33 NET_64 NET_62 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_62 NET_64 VDD33 P33 l=0.300u w=5.000u
M162 NET_5924 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M163 NET_5928 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M164 NET_5933 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M165 NET_5938 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M166 PAD NET_65 NET_5922 NET_1366 P33 l=0.300u w=30.000u
M167 NET_5922 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M168 PAD NET_65 NET_5926 NET_1366 P33 l=0.300u w=30.000u
M169 NET_5926 NET_50 VDD33 NET_1366 P33 l=0.300u w=30.000u
M170 NET_1366 PAD VDD33 NET_1366 P33 l=0.350u w=5.000u
M171 NET_1366 PAD VDD33 NET_1366 P33 l=0.350u w=5.000u
M172 VDD33 PAD NET_1366 NET_1366 P33 l=0.350u w=5.000u
M173 NET_50 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 NET_50 NET_53 VDD33 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_53 NET_50 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_53 NET_54 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_54 NET_53 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_44 NET_3549 VDD33 P33 l=0.300u w=5.000u
M179 NET_3549 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M180 NET_5947 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M181 NET_5951 NET_3507 VDD33 NET_1366 P33 l=0.300u w=30.000u
M182 NET_5924 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M183 NET_5928 NET_65 PAD NET_1366 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_65 NET_1366 P33 l=0.350u w=10.000u
M185 PAD VDD33 NET_1366 NET_1366 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBSD12

.subckt PBSL24   PAD OEN I C FP
M1 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M3 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M5 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M8 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M9 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M10 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_71 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_71 NET_72 NET_70 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M17 NET_75 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_75 VSS N18 l=0.180u w=2.000u
M19 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M25 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M27 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M29 NET_5934 OEN NET_75 VDD P18 l=0.180u w=5.000u
M30 NET_5934 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M32 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M33 NET_46 NET_75 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M35 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M39 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M40 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M41 VDD NET_72 NET_70 VDD P18 l=0.180u w=5.000u
M42 NET_70 NET_72 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_85 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_85 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_85 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_85 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M77 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M78 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M79 NET_49 NET_50 VSS VSS N33 l=0.350u w=4.400u
M80 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M81 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M82 NET_50 NET_70 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M84 NET_51 NET_66 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M86 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_72 NET_59 VSS N33 l=0.350u w=7.440u
M89 NET_59 NET_72 VSS VSS N33 l=0.350u w=7.440u
M90 NET_64 NET_3500 NET_62 VSS N33 l=0.350u w=8.000u
M91 NET_64 NET_61 VSS VSS N33 l=0.350u w=8.000u
M92 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M93 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M94 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M95 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M97 NET_90 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M98 NET_84 NET_90 NET_94 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_90 VSS VSS N33 l=0.350u w=8.000u
M100 NET_84 NET_94 VDD33 VSS N33 l=0.350u w=0.820u
M101 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M102 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M103 NET_5915 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M104 NET_5915 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M105 NET_5917 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M106 NET_5917 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M107 NET_1363 NET_1363 NET_1363 NET_1363 P33 l=1.070u w=5.000u
M108 VSS NET_94 NET_3547 VDD33 P33 l=0.300u w=5.100u
M109 VSS NET_94 NET_3547 VDD33 P33 l=0.300u w=5.100u
M110 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M111 PAD NET_62 NET_5908 NET_1363 P33 l=0.300u w=30.000u
M112 NET_5908 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M113 VDD33 NET_49 NET_5906 NET_1363 P33 l=0.300u w=30.000u
M114 NET_5906 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M115 PAD NET_62 NET_5913 NET_1363 P33 l=0.300u w=30.000u
M116 NET_5913 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M117 VDD33 NET_49 NET_5911 NET_1363 P33 l=0.300u w=30.000u
M118 NET_5911 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M119 NET_3547 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M120 NET_94 NET_90 NET_3547 VDD33 P33 l=0.300u w=5.000u
M121 NET_94 NET_90 NET_3547 VDD33 P33 l=0.300u w=5.000u
M122 NET_3547 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M124 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M125 NET_107 NET_94 VDD VDD P33 l=0.300u w=5.000u
M126 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M127 PAD NET_62 NET_5904 NET_1363 P33 l=0.300u w=30.000u
M128 NET_5904 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M129 NET_5902 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M130 NET_5902 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M131 PAD NET_62 NET_5894 NET_1363 P33 l=0.300u w=30.000u
M132 PAD NET_62 NET_5909 NET_1363 P33 l=0.300u w=30.000u
M133 NET_5909 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M134 NET_5903 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M135 NET_5903 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M136 PAD NET_62 NET_5898 NET_1363 P33 l=0.300u w=30.000u
M137 VDD33 NET_47 NET_85 VDD33 P33 l=0.300u w=4.600u
M138 VDD33 NET_49 NET_5892 NET_1363 P33 l=0.300u w=30.000u
M139 NET_5892 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M140 NET_5884 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M141 NET_5884 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M142 VDD33 NET_49 NET_5896 NET_1363 P33 l=0.300u w=30.000u
M143 NET_5896 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M144 NET_5889 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M145 NET_5889 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M146 VDD33 VSS NET_3500 VDD33 P33 l=0.300u w=5.000u
M147 NET_47 NET_89 VDD33 VDD33 P33 l=0.300u w=5.000u
M148 VDD33 NET_47 NET_89 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_49 NET_5882 NET_1363 P33 l=0.300u w=30.000u
M150 NET_5882 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M151 PAD NET_62 NET_5880 NET_1363 P33 l=0.300u w=30.000u
M152 NET_5880 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M153 NET_5871 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M154 VDD33 NET_49 NET_5887 NET_1363 P33 l=0.300u w=30.000u
M155 NET_5887 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M156 PAD NET_62 NET_5885 NET_1363 P33 l=0.300u w=30.000u
M157 NET_5885 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M158 NET_5875 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M159 VDD33 NET_61 NET_59 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_59 NET_61 VDD33 P33 l=0.300u w=5.000u
M161 PAD NET_62 NET_5869 NET_1363 P33 l=0.300u w=30.000u
M162 NET_5869 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M163 PAD NET_62 NET_5873 NET_1363 P33 l=0.300u w=30.000u
M164 NET_5873 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M165 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M166 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M167 VDD33 PAD NET_1363 NET_1363 P33 l=0.350u w=5.000u
M168 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M170 NET_49 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_50 NET_51 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M174 PAD VDD33 NET_1363 NET_1363 P33 l=0.350u w=15.000u
M175 NET_5894 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M176 NET_5871 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M177 NET_5898 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M178 NET_5875 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M179 PAD VDD33 NET_62 NET_1363 P33 l=0.350u w=10.000u
M180 NET_3547 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M181 VDD33 NET_45 NET_3547 VDD33 P33 l=0.300u w=5.000u
R1 PAD NET_45 300.135
.ends PBSL24

.subckt PBSL8   PAD OEN I C FP
M1 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M3 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M5 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M8 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M9 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M10 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_71 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_71 NET_72 NET_70 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M17 NET_75 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_75 VSS N18 l=0.180u w=2.000u
M19 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M25 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M27 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M29 NET_5936 OEN NET_75 VDD P18 l=0.180u w=5.000u
M30 NET_5936 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M32 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M33 NET_46 NET_75 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M35 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M39 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M40 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M41 VDD NET_72 NET_70 VDD P18 l=0.180u w=5.000u
M42 NET_70 NET_72 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_25 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M77 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M78 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M79 NET_49 NET_50 VSS VSS N33 l=0.350u w=4.600u
M80 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M81 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M82 NET_50 NET_70 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M84 NET_51 NET_66 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M86 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_72 NET_59 VSS N33 l=0.350u w=7.440u
M89 NET_59 NET_72 VSS VSS N33 l=0.350u w=7.440u
M90 NET_64 NET_3500 NET_62 VSS N33 l=0.350u w=8.000u
M91 NET_64 NET_61 VSS VSS N33 l=0.350u w=8.000u
M92 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M93 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M94 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M95 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M97 NET_90 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M98 NET_84 NET_90 NET_94 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_90 VSS VSS N33 l=0.350u w=8.000u
M100 NET_84 NET_94 VDD33 VSS N33 l=0.350u w=0.820u
M101 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M102 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M103 NET_5917 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M104 NET_5917 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M105 NET_5919 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M106 NET_5919 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M107 NET_1363 NET_1363 NET_1363 NET_1363 P33 l=1.070u w=5.000u
M108 VSS NET_94 NET_3549 VDD33 P33 l=0.300u w=5.100u
M109 VSS NET_94 NET_3549 VDD33 P33 l=0.300u w=5.100u
M110 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M111 PAD NET_62 NET_5910 NET_1363 P33 l=0.300u w=30.000u
M112 NET_5910 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M113 VDD33 NET_3500 NET_5908 NET_1363 P33 l=0.300u w=30.000u
M114 NET_5908 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M115 PAD NET_62 NET_5915 NET_1363 P33 l=0.300u w=30.000u
M116 NET_5915 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M117 VDD33 NET_3500 NET_5913 NET_1363 P33 l=0.300u w=30.000u
M118 NET_5913 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M119 NET_3549 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M120 NET_94 NET_90 NET_3549 VDD33 P33 l=0.300u w=5.000u
M121 NET_94 NET_90 NET_3549 VDD33 P33 l=0.300u w=5.000u
M122 NET_3549 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M124 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M125 NET_107 NET_94 VDD VDD P33 l=0.300u w=5.000u
M126 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M127 PAD NET_62 NET_5906 NET_1363 P33 l=0.300u w=30.000u
M128 NET_5906 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M129 NET_5904 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M130 NET_5904 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M131 PAD NET_62 NET_5896 NET_1363 P33 l=0.300u w=30.000u
M132 PAD NET_62 NET_5911 NET_1363 P33 l=0.300u w=30.000u
M133 NET_5911 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M134 NET_5905 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M135 NET_5905 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M136 PAD NET_62 NET_5900 NET_1363 P33 l=0.300u w=30.000u
M137 NET_85 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 VDD33 NET_3500 NET_5894 NET_1363 P33 l=0.300u w=30.000u
M139 NET_5894 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M140 NET_5886 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M141 NET_5886 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M142 VDD33 NET_3500 NET_5898 NET_1363 P33 l=0.300u w=30.000u
M143 NET_5898 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M144 NET_5891 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M145 NET_5891 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M146 VDD33 VSS NET_3500 VDD33 P33 l=0.300u w=5.000u
M147 NET_47 NET_89 VDD33 VDD33 P33 l=0.300u w=5.000u
M148 VDD33 NET_47 NET_89 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_49 NET_5884 NET_1363 P33 l=0.300u w=30.000u
M150 NET_5884 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M151 PAD NET_62 NET_5882 NET_1363 P33 l=0.300u w=30.000u
M152 NET_5882 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M153 NET_5873 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M154 VDD33 NET_49 NET_5889 NET_1363 P33 l=0.300u w=30.000u
M155 NET_5889 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M156 PAD NET_62 NET_5887 NET_1363 P33 l=0.300u w=30.000u
M157 NET_5887 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M158 NET_5877 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M159 VDD33 NET_61 NET_59 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_59 NET_61 VDD33 P33 l=0.300u w=5.000u
M161 PAD NET_62 NET_5871 NET_1363 P33 l=0.300u w=30.000u
M162 NET_5871 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M163 PAD NET_62 NET_5875 NET_1363 P33 l=0.300u w=30.000u
M164 NET_5875 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M165 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M166 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M167 VDD33 PAD NET_1363 NET_1363 P33 l=0.350u w=5.000u
M168 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M170 NET_49 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_50 NET_51 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M174 PAD VDD33 NET_1363 NET_1363 P33 l=0.350u w=15.000u
M175 NET_5896 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M176 NET_5873 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M177 NET_5900 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M178 NET_5877 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M179 PAD VDD33 NET_62 NET_1363 P33 l=0.350u w=10.000u
M180 NET_3549 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M181 VDD33 NET_45 NET_3549 VDD33 P33 l=0.300u w=5.000u
R1 PAD NET_45 300.135
.ends PBSL8

.subckt PBSL16   PAD OEN I C FP
M1 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M3 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M5 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M8 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M9 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M10 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_71 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_71 NET_72 NET_70 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M17 NET_75 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_75 VSS N18 l=0.180u w=2.000u
M19 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_75 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M25 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M27 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M29 NET_5926 OEN NET_75 VDD P18 l=0.180u w=5.000u
M30 NET_5926 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M32 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M33 NET_46 NET_75 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_75 NET_46 VDD P18 l=0.180u w=5.000u
M35 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M39 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M40 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M41 VDD NET_72 NET_70 VDD P18 l=0.180u w=5.000u
M42 NET_70 NET_72 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_85 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_85 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M77 VSS NET_47 NET_85 VSS N33 l=0.350u w=8.000u
M78 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M79 NET_49 NET_50 VSS VSS N33 l=0.350u w=3.400u
M80 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M81 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M82 NET_50 NET_70 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M84 NET_51 NET_66 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M86 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_72 NET_59 VSS N33 l=0.350u w=7.440u
M89 NET_59 NET_72 VSS VSS N33 l=0.350u w=7.440u
M90 NET_64 NET_3500 NET_62 VSS N33 l=0.350u w=8.000u
M91 NET_64 NET_61 VSS VSS N33 l=0.350u w=8.000u
M92 NET_89 NET_46 VSS VSS N33 l=0.350u w=8.000u
M93 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M94 NET_47 NET_75 VSS VSS N33 l=0.350u w=8.000u
M95 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M97 NET_90 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M98 NET_84 NET_90 NET_94 VSS N33 l=0.350u w=8.000u
M99 NET_84 NET_90 VSS VSS N33 l=0.350u w=8.000u
M100 NET_84 NET_94 VDD33 VSS N33 l=0.350u w=0.820u
M101 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M102 VSS NET_94 NET_107 VSS N33 l=0.350u w=2.000u
M103 NET_5907 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M104 NET_5907 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M105 NET_5909 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M106 NET_5909 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M107 NET_1363 NET_1363 NET_1363 NET_1363 P33 l=1.070u w=5.000u
M108 VSS NET_94 NET_3547 VDD33 P33 l=0.300u w=5.100u
M109 VSS NET_94 NET_3547 VDD33 P33 l=0.300u w=5.100u
M110 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M111 PAD NET_62 NET_5900 NET_1363 P33 l=0.300u w=30.000u
M112 NET_5900 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M113 VDD33 NET_3500 NET_5898 NET_1363 P33 l=0.300u w=30.000u
M114 NET_5898 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M115 PAD NET_62 NET_5905 NET_1363 P33 l=0.300u w=30.000u
M116 NET_5905 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M117 VDD33 NET_3500 NET_5903 NET_1363 P33 l=0.300u w=30.000u
M118 NET_5903 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M119 NET_94 NET_90 NET_3547 VDD33 P33 l=0.300u w=5.000u
M120 NET_94 NET_90 NET_3547 VDD33 P33 l=0.300u w=5.000u
M121 NET_3547 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M122 NET_3547 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
M123 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M124 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M125 NET_107 NET_94 VDD VDD P33 l=0.300u w=5.000u
M126 VDD NET_94 NET_107 VDD P33 l=0.300u w=5.000u
M127 PAD NET_62 NET_5896 NET_1363 P33 l=0.300u w=30.000u
M128 NET_5896 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M129 NET_5894 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M130 NET_5894 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M131 PAD NET_62 NET_5886 NET_1363 P33 l=0.300u w=30.000u
M132 PAD NET_62 NET_5901 NET_1363 P33 l=0.300u w=30.000u
M133 NET_5901 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M134 NET_5895 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M135 NET_5895 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M136 PAD NET_62 NET_5890 NET_1363 P33 l=0.300u w=30.000u
M137 NET_85 NET_47 VDD33 VDD33 P33 l=0.300u w=3.600u
M138 VDD33 NET_49 NET_5884 NET_1363 P33 l=0.300u w=30.000u
M139 NET_5884 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M140 NET_5876 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M141 NET_5876 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M142 VDD33 NET_49 NET_5888 NET_1363 P33 l=0.300u w=30.000u
M143 NET_5888 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M144 NET_5881 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M145 NET_5881 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M146 VDD33 VSS NET_3500 VDD33 P33 l=0.300u w=5.000u
M147 NET_47 NET_89 VDD33 VDD33 P33 l=0.300u w=5.000u
M148 VDD33 NET_47 NET_89 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_49 NET_5874 NET_1363 P33 l=0.300u w=30.000u
M150 NET_5874 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M151 PAD NET_62 NET_5872 NET_1363 P33 l=0.300u w=30.000u
M152 NET_5872 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M153 NET_5863 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M154 VDD33 NET_49 NET_5879 NET_1363 P33 l=0.300u w=30.000u
M155 NET_5879 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M156 PAD NET_62 NET_5877 NET_1363 P33 l=0.300u w=30.000u
M157 NET_5877 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M158 NET_5867 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M159 VDD33 NET_61 NET_59 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_59 NET_61 VDD33 P33 l=0.300u w=5.000u
M161 PAD NET_62 NET_5861 NET_1363 P33 l=0.300u w=30.000u
M162 NET_5861 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M163 PAD NET_62 NET_5865 NET_1363 P33 l=0.300u w=30.000u
M164 NET_5865 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M165 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M166 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M167 VDD33 PAD NET_1363 NET_1363 P33 l=0.350u w=5.000u
M168 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M170 NET_49 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_50 NET_51 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M174 PAD VDD33 NET_1363 NET_1363 P33 l=0.350u w=15.000u
M175 NET_5886 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M176 NET_5863 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M177 NET_5890 NET_49 VDD33 NET_1363 P33 l=0.300u w=30.000u
M178 NET_5867 NET_62 PAD NET_1363 P33 l=0.300u w=30.000u
M179 PAD VDD33 NET_62 NET_1363 P33 l=0.350u w=10.000u
M180 VDD33 NET_45 NET_3547 VDD33 P33 l=0.300u w=5.000u
M181 NET_3547 NET_94 VSS VDD33 P33 l=0.300u w=5.100u
R1 PAD NET_45 300.135
.ends PBSL16

.subckt PBSL12   PAD OEN I C FP
M1 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M3 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M5 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M8 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M9 VSS NET_71 NET_67 VSS N18 l=0.180u w=4.000u
M10 VSS NET_71 NET_67 VSS N18 l=0.180u w=4.000u
M11 NET_72 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_72 NET_73 NET_71 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M17 NET_76 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_76 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_76 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M23 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M24 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M25 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M26 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M27 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M29 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M30 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_73 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_73 VDD P18 l=0.180u w=5.000u
M33 NET_5959 OEN NET_76 VDD P18 l=0.180u w=5.000u
M34 NET_5959 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_46 NET_76 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M37 VDD NET_71 NET_67 VDD P18 l=0.180u w=5.000u
M38 VDD NET_71 NET_67 VDD P18 l=0.180u w=5.000u
M39 NET_71 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_71 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_73 NET_71 VDD P18 l=0.180u w=5.000u
M42 NET_71 NET_73 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_86 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_86 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_47 NET_86 VSS N33 l=0.350u w=8.000u
M77 VSS NET_47 NET_86 VSS N33 l=0.350u w=8.000u
M78 VSS NET_51 NET_48 VSS N33 l=0.350u w=5.000u
M79 VSS NET_51 NET_48 VSS N33 l=0.350u w=5.000u
M80 VSS NET_71 NET_51 VSS N33 l=0.350u w=5.330u
M81 VSS NET_71 NET_51 VSS N33 l=0.350u w=5.330u
M82 NET_51 NET_71 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_67 NET_52 VSS N33 l=0.350u w=5.330u
M84 NET_52 NET_67 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_67 NET_52 VSS N33 l=0.350u w=5.330u
M86 NET_62 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_62 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_73 NET_60 VSS N33 l=0.350u w=7.440u
M89 NET_60 NET_73 VSS VSS N33 l=0.350u w=7.440u
M90 NET_65 NET_3501 NET_63 VSS N33 l=0.350u w=8.000u
M91 NET_65 NET_62 VSS VSS N33 l=0.350u w=8.000u
M92 NET_90 NET_46 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_76 NET_47 VSS N33 l=0.350u w=8.000u
M94 VSS NET_76 NET_47 VSS N33 l=0.350u w=8.000u
M95 NET_90 NET_46 VSS VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M97 NET_45 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M98 NET_91 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M99 NET_85 NET_91 NET_95 VSS N33 l=0.350u w=8.000u
M100 NET_85 NET_91 VSS VSS N33 l=0.350u w=8.000u
M101 NET_85 NET_95 VDD33 VSS N33 l=0.350u w=0.820u
M102 VSS NET_95 NET_108 VSS N33 l=0.350u w=2.000u
M103 VSS NET_95 NET_108 VSS N33 l=0.350u w=2.000u
M104 NET_5940 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M105 NET_5940 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M106 NET_5942 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M107 NET_5942 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M108 NET_1364 NET_1364 NET_1364 NET_1364 P33 l=1.070u w=5.000u
M109 VSS NET_95 NET_3551 VDD33 P33 l=0.300u w=5.100u
M110 VSS NET_95 NET_3551 VDD33 P33 l=0.300u w=5.100u
M111 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M112 PAD NET_63 NET_5933 NET_1364 P33 l=0.300u w=30.000u
M113 NET_5933 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M114 VDD33 NET_3501 NET_5931 NET_1364 P33 l=0.300u w=30.000u
M115 NET_5931 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M116 PAD NET_63 NET_5938 NET_1364 P33 l=0.300u w=30.000u
M117 NET_5938 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_3501 NET_5936 NET_1364 P33 l=0.300u w=30.000u
M119 NET_5936 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M120 NET_3551 NET_95 VSS VDD33 P33 l=0.300u w=5.100u
M121 NET_95 NET_91 NET_3551 VDD33 P33 l=0.300u w=5.000u
M122 NET_95 NET_91 NET_3551 VDD33 P33 l=0.300u w=5.000u
M123 NET_3551 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M125 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M126 NET_108 NET_95 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_95 NET_108 VDD P33 l=0.300u w=5.000u
M128 PAD NET_63 NET_5929 NET_1364 P33 l=0.300u w=30.000u
M129 PAD NET_63 NET_5934 NET_1364 P33 l=0.300u w=30.000u
M130 NET_5927 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M131 NET_5927 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M132 PAD NET_63 NET_5919 NET_1364 P33 l=0.300u w=30.000u
M133 NET_5928 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M134 NET_5928 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M135 PAD NET_63 NET_5923 NET_1364 P33 l=0.300u w=30.000u
M136 VDD33 NET_47 NET_86 VDD33 P33 l=0.300u w=4.800u
M137 VDD33 NET_47 NET_86 VDD33 P33 l=0.300u w=4.800u
M138 NET_5929 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M139 NET_5934 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M140 VDD33 NET_48 NET_5917 NET_1364 P33 l=0.300u w=30.000u
M141 NET_5917 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M142 VDD33 NET_48 NET_5921 NET_1364 P33 l=0.300u w=30.000u
M143 NET_5921 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M144 NET_5909 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M145 NET_5909 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M146 NET_5914 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M147 NET_5914 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3501 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_47 NET_90 VDD33 P33 l=0.300u w=5.000u
M150 NET_47 NET_90 VDD33 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_48 NET_5907 NET_1364 P33 l=0.300u w=30.000u
M152 NET_5907 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M153 PAD NET_63 NET_5905 NET_1364 P33 l=0.300u w=30.000u
M154 VDD33 NET_48 NET_5912 NET_1364 P33 l=0.300u w=30.000u
M155 NET_5912 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M156 PAD NET_63 NET_5910 NET_1364 P33 l=0.300u w=30.000u
M157 VDD33 NET_62 NET_60 VDD33 P33 l=0.300u w=5.000u
M158 VDD33 NET_60 NET_62 VDD33 P33 l=0.300u w=5.000u
M159 NET_5896 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M160 NET_5900 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M161 NET_5905 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M162 NET_5910 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M163 PAD NET_63 NET_5894 NET_1364 P33 l=0.300u w=30.000u
M164 NET_5894 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M165 PAD NET_63 NET_5898 NET_1364 P33 l=0.300u w=30.000u
M166 NET_5898 NET_48 VDD33 NET_1364 P33 l=0.300u w=30.000u
M167 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M168 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M169 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M170 VDD33 NET_51 NET_48 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_51 NET_48 VDD33 P33 l=0.300u w=5.000u
M172 NET_48 NET_51 VDD33 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_51 NET_48 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_51 NET_52 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_52 NET_51 VDD33 P33 l=0.300u w=5.000u
M176 NET_3551 NET_95 VSS VDD33 P33 l=0.300u w=5.100u
M177 VDD33 NET_45 NET_3551 VDD33 P33 l=0.300u w=5.000u
M178 NET_5919 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M179 NET_5923 NET_3501 VDD33 NET_1364 P33 l=0.300u w=30.000u
M180 NET_5896 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M181 NET_5900 NET_63 PAD NET_1364 P33 l=0.300u w=30.000u
M182 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
M183 PAD VDD33 NET_63 NET_1364 P33 l=0.350u w=10.000u
R1 PAD NET_45 300.135
.ends PBSL12

.subckt PBS8   PAD OEN I C FP
M1 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M3 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M5 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M8 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M9 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M10 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M11 NET_52 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_52 NET_53 NET_51 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M17 NET_56 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_56 VSS N18 l=0.180u w=2.000u
M19 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M20 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M21 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M23 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M24 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M25 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M27 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M30 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M33 NET_5983 OEN NET_56 VDD P18 l=0.180u w=5.000u
M34 NET_5983 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_61 NET_56 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M37 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M38 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M39 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_53 NET_51 VDD P18 l=0.180u w=5.000u
M42 NET_51 NET_53 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_25 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M77 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M78 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M79 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M80 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M81 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M82 NET_68 NET_51 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M84 NET_69 NET_47 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M86 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_53 NET_77 VSS N33 l=0.350u w=7.440u
M89 NET_77 NET_53 VSS VSS N33 l=0.350u w=7.440u
M90 NET_82 NET_3505 NET_80 VSS N33 l=0.350u w=8.000u
M91 NET_82 NET_79 VSS VSS N33 l=0.350u w=8.000u
M92 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M94 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M95 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M97 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M98 NET_105 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M99 NET_85 NET_105 NET_109 VSS N33 l=0.350u w=8.000u
M100 NET_85 NET_105 VSS VSS N33 l=0.350u w=8.000u
M101 NET_85 NET_109 VDD33 VSS N33 l=0.350u w=0.820u
M102 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M103 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M104 NET_5964 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M105 NET_5964 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M106 NET_5966 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M107 NET_5966 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M108 NET_1364 NET_1364 NET_1364 NET_1364 P33 l=1.070u w=5.000u
M109 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M110 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M111 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M112 PAD NET_80 NET_5957 NET_1364 P33 l=0.300u w=30.000u
M113 NET_5957 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M114 VDD33 NET_3505 NET_5955 NET_1364 P33 l=0.300u w=30.000u
M115 NET_5955 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M116 PAD NET_80 NET_5962 NET_1364 P33 l=0.300u w=30.000u
M117 NET_5962 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_3505 NET_5960 NET_1364 P33 l=0.300u w=30.000u
M119 NET_5960 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M120 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M121 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M122 NET_3547 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M124 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M125 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M126 NET_96 NET_109 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M128 PAD NET_80 NET_5953 NET_1364 P33 l=0.300u w=30.000u
M129 PAD NET_80 NET_5958 NET_1364 P33 l=0.300u w=30.000u
M130 NET_5951 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M131 NET_5951 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M132 PAD NET_80 NET_5943 NET_1364 P33 l=0.300u w=30.000u
M133 NET_5952 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M134 NET_5952 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M135 PAD NET_80 NET_5947 NET_1364 P33 l=0.300u w=30.000u
M136 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M137 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_5953 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M139 NET_5958 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M140 VDD33 NET_3505 NET_5941 NET_1364 P33 l=0.300u w=30.000u
M141 NET_5941 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M142 VDD33 NET_3505 NET_5945 NET_1364 P33 l=0.300u w=30.000u
M143 NET_5945 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M144 VDD33 NET_83 NET_100 VDD33 P33 l=0.300u w=5.000u
M145 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M146 NET_5933 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M147 NET_5933 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M148 NET_5938 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M149 NET_5938 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M150 VDD33 VSS NET_3505 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_83 NET_104 VDD33 P33 l=0.300u w=5.000u
M152 NET_83 NET_104 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_65 NET_5931 NET_1364 P33 l=0.300u w=30.000u
M154 NET_5931 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M155 PAD NET_80 NET_5929 NET_1364 P33 l=0.300u w=30.000u
M156 VDD33 NET_65 NET_5936 NET_1364 P33 l=0.300u w=30.000u
M157 NET_5936 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M158 PAD NET_80 NET_5934 NET_1364 P33 l=0.300u w=30.000u
M159 VDD33 NET_79 NET_77 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_77 NET_79 VDD33 P33 l=0.300u w=5.000u
M161 NET_5920 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M162 NET_5924 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M163 NET_5929 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M164 NET_5934 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M165 PAD NET_80 NET_5918 NET_1364 P33 l=0.300u w=30.000u
M166 NET_5918 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M167 PAD NET_80 NET_5922 NET_1364 P33 l=0.300u w=30.000u
M168 NET_5922 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M169 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M170 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M171 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M172 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M173 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_68 NET_65 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_68 NET_69 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_69 NET_68 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_45 NET_3547 VDD33 P33 l=0.300u w=5.000u
M178 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M179 NET_5943 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M180 NET_5947 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M181 NET_5920 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M182 NET_5924 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
M184 PAD VDD33 NET_80 NET_1364 P33 l=0.350u w=10.000u
R1 PAD NET_45 300.135
.ends PBS8

.subckt PBS4   PAD I OEN C FP
M1 VSS NET_108 NET_85 VSS N18 l=0.180u w=2.000u
M2 VSS NET_108 NET_85 VSS N18 l=0.180u w=2.000u
M3 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M5 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M7 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 NET_79 NET_74 VSS VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_79 VSS N18 l=0.180u w=2.000u
M21 VDD NET_108 NET_85 VDD P18 l=0.180u w=5.000u
M22 VDD NET_108 NET_85 VDD P18 l=0.180u w=5.000u
M23 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M25 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M27 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M29 NET_5968 OEN NET_74 VDD P18 l=0.180u w=5.000u
M30 NET_5968 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_74 NET_79 VDD P18 l=0.180u w=5.000u
M32 VDD NET_74 NET_79 VDD P18 l=0.180u w=5.000u
M33 NET_79 NET_74 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_79 VDD P18 l=0.180u w=5.000u
M35 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M39 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M40 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M41 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M42 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_25 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_95 NET_10 VSS VSS N33 l=0.350u w=4.000u
M77 NET_95 NET_10 VSS VSS N33 l=0.350u w=4.000u
M78 VSS NET_10 NET_95 VSS N33 l=0.350u w=4.000u
M79 VSS NET_49 NET_46 VSS N33 l=0.350u w=8.000u
M80 VSS NET_49 NET_46 VSS N33 l=0.350u w=8.000u
M81 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M82 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M83 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M84 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M85 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M86 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M87 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M88 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M89 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M90 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M91 NET_63 NET_3515 NET_61 VSS N33 l=0.350u w=8.000u
M92 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M93 NET_93 NET_79 VSS VSS N33 l=0.350u w=8.000u
M94 VSS NET_74 NET_10 VSS N33 l=0.350u w=8.000u
M95 VSS NET_74 NET_10 VSS N33 l=0.350u w=8.000u
M96 NET_93 NET_79 VSS VSS N33 l=0.350u w=8.000u
M97 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M98 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M99 NET_88 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M100 NET_11 NET_88 NET_98 VSS N33 l=0.350u w=8.000u
M101 NET_11 NET_88 VSS VSS N33 l=0.350u w=8.000u
M102 VDD33 NET_98 NET_11 VSS N33 l=0.350u w=0.820u
M103 VSS NET_98 NET_108 VSS N33 l=0.350u w=2.000u
M104 VSS NET_98 NET_108 VSS N33 l=0.350u w=2.000u
M105 NET_1365 NET_1365 NET_1365 NET_1365 P33 l=1.070u w=5.000u
M106 NET_5951 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M107 NET_5951 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M108 NET_5953 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M109 NET_5953 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M110 VSS NET_98 NET_3556 VDD33 P33 l=0.300u w=5.100u
M111 VSS NET_98 NET_3556 VDD33 P33 l=0.300u w=5.100u
M112 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M113 PAD NET_61 NET_5942 NET_1365 P33 l=0.300u w=30.000u
M114 NET_5942 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M115 VDD33 NET_3515 NET_5940 NET_1365 P33 l=0.300u w=30.000u
M116 NET_5940 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M117 PAD NET_61 NET_5947 NET_1365 P33 l=0.300u w=30.000u
M118 NET_5947 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M119 VDD33 NET_3515 NET_5945 NET_1365 P33 l=0.300u w=30.000u
M120 NET_5945 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M121 NET_98 NET_88 NET_3556 VDD33 P33 l=0.300u w=5.000u
M122 NET_98 NET_88 NET_3556 VDD33 P33 l=0.300u w=5.000u
M123 NET_3556 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 NET_3556 NET_98 VSS VDD33 P33 l=0.300u w=5.100u
M125 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M126 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M127 NET_108 NET_98 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_98 NET_108 VDD P33 l=0.300u w=5.000u
M129 PAD NET_61 NET_5938 NET_1365 P33 l=0.300u w=30.000u
M130 NET_5938 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M131 NET_5936 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M132 NET_5936 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M133 PAD NET_61 NET_5928 NET_1365 P33 l=0.300u w=30.000u
M134 PAD NET_61 NET_5943 NET_1365 P33 l=0.300u w=30.000u
M135 NET_5943 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M136 NET_5937 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M137 NET_5937 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M138 PAD NET_61 NET_5932 NET_1365 P33 l=0.300u w=30.000u
M139 NET_95 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M140 NET_95 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_3515 NET_5926 NET_1365 P33 l=0.300u w=30.000u
M142 NET_5926 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M143 NET_5918 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M144 NET_5918 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M145 VDD33 NET_3515 NET_5930 NET_1365 P33 l=0.300u w=30.000u
M146 NET_5930 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M147 NET_5923 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M148 NET_5923 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M149 VDD33 VSS NET_3515 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_10 NET_95 VDD33 P33 l=0.300u w=5.000u
M151 NET_10 NET_93 VDD33 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_10 NET_93 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_3515 NET_5916 NET_1365 P33 l=0.300u w=30.000u
M154 NET_5916 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M155 PAD NET_61 NET_5914 NET_1365 P33 l=0.300u w=30.000u
M156 NET_5914 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M157 NET_5905 NET_46 VDD33 NET_1365 P33 l=0.300u w=30.000u
M158 VDD33 NET_3515 NET_5921 NET_1365 P33 l=0.300u w=30.000u
M159 NET_5921 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M160 PAD NET_61 NET_5919 NET_1365 P33 l=0.300u w=30.000u
M161 NET_5919 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M162 NET_5909 NET_46 VDD33 NET_1365 P33 l=0.300u w=30.000u
M163 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M165 PAD NET_61 NET_5903 NET_1365 P33 l=0.300u w=30.000u
M166 NET_5903 NET_46 VDD33 NET_1365 P33 l=0.300u w=30.000u
M167 PAD NET_61 NET_5907 NET_1365 P33 l=0.300u w=30.000u
M168 NET_5907 NET_46 VDD33 NET_1365 P33 l=0.300u w=30.000u
M169 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M170 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M171 VDD33 PAD NET_1365 NET_1365 P33 l=0.350u w=5.000u
M172 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M176 PAD VDD33 NET_61 NET_1365 P33 l=0.350u w=10.000u
M177 PAD VDD33 NET_1365 NET_1365 P33 l=0.350u w=15.000u
M178 NET_5928 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M179 NET_5905 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M180 NET_5932 NET_3515 VDD33 NET_1365 P33 l=0.300u w=30.000u
M181 NET_5909 NET_61 PAD NET_1365 P33 l=0.300u w=30.000u
M182 VDD33 NET_45 NET_3556 VDD33 P33 l=0.300u w=5.000u
M183 NET_3556 NET_98 VSS VDD33 P33 l=0.300u w=5.100u
R1 PAD NET_45 300.135
.ends PBS4

.subckt PBS24   PAD OEN I C FP
M1 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M3 C NET_92 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M5 C NET_92 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_95 NET_92 VSS N18 l=0.180u w=2.000u
M8 VSS NET_95 NET_92 VSS N18 l=0.180u w=2.000u
M9 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M10 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M11 NET_52 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_52 NET_53 NET_51 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M17 NET_56 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_56 VSS N18 l=0.180u w=2.000u
M19 NET_61 NET_56 VSS VSS N18 l=0.180u w=2.000u
M20 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M21 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_95 NET_92 VDD P18 l=0.180u w=5.000u
M23 VDD NET_95 NET_92 VDD P18 l=0.180u w=5.000u
M24 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M25 C NET_92 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M27 C NET_92 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M32 NET_5982 OEN NET_56 VDD P18 l=0.180u w=5.000u
M33 NET_5982 I VDD VDD P18 l=0.180u w=5.000u
M34 NET_61 NET_56 VDD VDD P18 l=0.180u w=5.000u
M35 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M36 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M37 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M38 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_53 NET_51 VDD P18 l=0.180u w=5.000u
M41 NET_51 NET_53 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_100 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_100 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_100 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_100 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_100 NET_10 VSS VSS N33 l=0.350u w=8.000u
M77 NET_100 NET_10 VSS VSS N33 l=0.350u w=8.000u
M78 VSS NET_10 NET_100 VSS N33 l=0.350u w=8.000u
M79 VSS NET_68 NET_65 VSS N33 l=0.350u w=8.000u
M80 VSS NET_68 NET_65 VSS N33 l=0.350u w=8.000u
M81 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M82 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M83 NET_68 NET_51 VSS VSS N33 l=0.350u w=5.330u
M84 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M85 NET_69 NET_47 VSS VSS N33 l=0.350u w=5.330u
M86 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M87 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M88 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M89 VSS NET_53 NET_77 VSS N33 l=0.350u w=7.440u
M90 NET_77 NET_53 VSS VSS N33 l=0.350u w=7.440u
M91 NET_82 NET_3503 NET_80 VSS N33 l=0.350u w=8.000u
M92 NET_82 NET_79 VSS VSS N33 l=0.350u w=8.000u
M93 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M94 VSS NET_56 NET_10 VSS N33 l=0.350u w=8.000u
M95 VSS NET_56 NET_10 VSS N33 l=0.350u w=8.000u
M96 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M97 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M98 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M99 NET_105 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M100 NET_11 NET_105 NET_109 VSS N33 l=0.350u w=8.000u
M101 NET_11 NET_105 VSS VSS N33 l=0.350u w=8.000u
M102 VDD33 NET_109 NET_11 VSS N33 l=0.350u w=0.820u
M103 VSS NET_109 NET_95 VSS N33 l=0.350u w=2.000u
M104 VSS NET_109 NET_95 VSS N33 l=0.350u w=2.000u
M105 NET_5963 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M106 NET_5963 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M107 NET_5965 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M108 NET_5965 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M109 NET_1365 NET_1365 NET_1365 NET_1365 P33 l=1.070u w=5.000u
M110 VSS NET_109 NET_3544 VDD33 P33 l=0.300u w=5.100u
M111 VSS NET_109 NET_3544 VDD33 P33 l=0.300u w=5.100u
M112 VDD NET_109 NET_95 VDD P33 l=0.300u w=5.000u
M113 PAD NET_80 NET_5956 NET_1365 P33 l=0.300u w=30.000u
M114 NET_5956 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M115 VDD33 NET_65 NET_5954 NET_1365 P33 l=0.300u w=30.000u
M116 NET_5954 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M117 PAD NET_80 NET_5961 NET_1365 P33 l=0.300u w=30.000u
M118 NET_5961 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M119 VDD33 NET_65 NET_5959 NET_1365 P33 l=0.300u w=30.000u
M120 NET_5959 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M121 NET_109 NET_105 NET_3544 VDD33 P33 l=0.300u w=5.000u
M122 NET_109 NET_105 NET_3544 VDD33 P33 l=0.300u w=5.000u
M123 NET_3544 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 NET_3544 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M125 VDD NET_109 NET_95 VDD P33 l=0.300u w=5.000u
M126 VDD NET_109 NET_95 VDD P33 l=0.300u w=5.000u
M127 NET_95 NET_109 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_109 NET_95 VDD P33 l=0.300u w=5.000u
M129 PAD NET_80 NET_5952 NET_1365 P33 l=0.300u w=30.000u
M130 PAD NET_80 NET_5957 NET_1365 P33 l=0.300u w=30.000u
M131 NET_5950 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M132 NET_5950 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M133 PAD NET_80 NET_5942 NET_1365 P33 l=0.300u w=30.000u
M134 NET_5951 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M135 NET_5951 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M136 PAD NET_80 NET_5946 NET_1365 P33 l=0.300u w=30.000u
M137 NET_100 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_100 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 NET_5952 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M140 NET_5957 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M141 VDD33 NET_65 NET_5940 NET_1365 P33 l=0.300u w=30.000u
M142 NET_5940 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M143 VDD33 NET_65 NET_5944 NET_1365 P33 l=0.300u w=30.000u
M144 NET_5944 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M145 VDD33 NET_10 NET_100 VDD33 P33 l=0.300u w=5.000u
M146 NET_5932 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M147 NET_5932 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M148 NET_5937 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M149 NET_5937 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M150 VDD33 VSS NET_3503 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_10 NET_104 VDD33 P33 l=0.300u w=5.000u
M152 NET_10 NET_104 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_65 NET_5930 NET_1365 P33 l=0.300u w=30.000u
M154 NET_5930 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M155 PAD NET_80 NET_5928 NET_1365 P33 l=0.300u w=30.000u
M156 VDD33 NET_65 NET_5935 NET_1365 P33 l=0.300u w=30.000u
M157 NET_5935 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M158 PAD NET_80 NET_5933 NET_1365 P33 l=0.300u w=30.000u
M159 VDD33 NET_79 NET_77 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_77 NET_79 VDD33 P33 l=0.300u w=5.000u
M161 NET_5919 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M162 NET_5923 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M163 NET_5928 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M164 NET_5933 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M165 PAD NET_80 NET_5917 NET_1365 P33 l=0.300u w=30.000u
M166 NET_5917 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M167 PAD NET_80 NET_5921 NET_1365 P33 l=0.300u w=30.000u
M168 NET_5921 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M169 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M170 NET_1365 PAD VDD33 NET_1365 P33 l=0.350u w=5.000u
M171 VDD33 PAD NET_1365 NET_1365 P33 l=0.350u w=5.000u
M172 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M173 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_68 NET_65 VDD33 P33 l=0.300u w=5.000u
M175 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_68 NET_65 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_68 NET_69 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_69 NET_68 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_45 NET_3544 VDD33 P33 l=0.300u w=5.000u
M180 NET_3544 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M181 NET_5942 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M182 NET_5946 NET_65 VDD33 NET_1365 P33 l=0.300u w=30.000u
M183 NET_5919 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M184 NET_5923 NET_80 PAD NET_1365 P33 l=0.300u w=30.000u
M185 PAD VDD33 NET_80 NET_1365 P33 l=0.350u w=10.000u
M186 PAD VDD33 NET_1365 NET_1365 P33 l=0.350u w=15.000u
R1 PAD NET_45 300.135
.ends PBS24

.subckt PBS2   PAD OEN I C FP
M1 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M3 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M5 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M8 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M9 VSS NET_71 NET_67 VSS N18 l=0.180u w=4.000u
M10 VSS NET_71 NET_67 VSS N18 l=0.180u w=4.000u
M11 NET_72 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_72 NET_73 NET_71 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M17 NET_76 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_76 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_76 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M22 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M23 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M25 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M27 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M29 NET_5957 OEN NET_76 VDD P18 l=0.180u w=5.000u
M30 NET_5957 I VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M32 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M33 NET_46 NET_76 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_76 NET_46 VDD P18 l=0.180u w=5.000u
M35 NET_71 I VDD VDD P18 l=0.180u w=5.000u
M36 NET_71 I VDD VDD P18 l=0.180u w=5.000u
M37 VDD OEN NET_73 VDD P18 l=0.180u w=5.000u
M38 VDD OEN NET_73 VDD P18 l=0.180u w=5.000u
M39 VDD NET_71 NET_67 VDD P18 l=0.180u w=5.000u
M40 VDD NET_71 NET_67 VDD P18 l=0.180u w=5.000u
M41 VDD NET_73 NET_71 VDD P18 l=0.180u w=5.000u
M42 NET_71 NET_73 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_25 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_95 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_25 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_47 NET_95 VSS N33 l=0.350u w=4.000u
M77 VSS NET_47 NET_95 VSS N33 l=0.350u w=4.000u
M78 NET_52 OEN VSS VSS N33 l=0.350u w=7.440u
M79 NET_52 OEN VSS VSS N33 l=0.350u w=7.440u
M80 VSS NET_73 NET_50 VSS N33 l=0.350u w=7.440u
M81 NET_50 NET_73 VSS VSS N33 l=0.350u w=7.440u
M82 NET_55 NET_3510 NET_53 VSS N33 l=0.350u w=8.000u
M83 NET_55 NET_52 VSS VSS N33 l=0.350u w=8.000u
M84 VSS NET_71 NET_56 VSS N33 l=0.350u w=5.330u
M85 VSS NET_71 NET_56 VSS N33 l=0.350u w=5.330u
M86 NET_56 NET_71 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_67 NET_57 VSS N33 l=0.350u w=5.330u
M88 NET_57 NET_67 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_67 NET_57 VSS N33 l=0.350u w=5.330u
M90 NET_87 NET_46 VSS VSS N33 l=0.350u w=8.000u
M91 VSS NET_76 NET_47 VSS N33 l=0.350u w=8.000u
M92 VSS NET_76 NET_47 VSS N33 l=0.350u w=8.000u
M93 VSS NET_56 NET_64 VSS N33 l=0.350u w=4.000u
M94 VSS NET_56 NET_64 VSS N33 l=0.350u w=4.000u
M95 NET_87 NET_46 VSS VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M97 NET_45 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M98 NET_88 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M99 NET_85 NET_88 NET_92 VSS N33 l=0.350u w=8.000u
M100 NET_85 NET_88 VSS VSS N33 l=0.350u w=8.000u
M101 NET_85 NET_92 VDD33 VSS N33 l=0.350u w=0.820u
M102 VSS NET_92 NET_108 VSS N33 l=0.350u w=2.000u
M103 VSS NET_92 NET_108 VSS N33 l=0.350u w=2.000u
M104 VSS NET_92 NET_3564 VDD33 P33 l=0.300u w=5.100u
M105 VSS NET_92 NET_3564 VDD33 P33 l=0.300u w=5.100u
M106 NET_5938 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M107 NET_5938 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M108 NET_5940 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M109 NET_5940 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M110 NET_1364 NET_1364 NET_1364 NET_1364 P33 l=1.070u w=5.000u
M111 VDD NET_92 NET_108 VDD P33 l=0.300u w=5.000u
M112 NET_92 NET_88 NET_3564 VDD33 P33 l=0.300u w=5.000u
M113 NET_92 NET_88 NET_3564 VDD33 P33 l=0.300u w=5.000u
M114 NET_3564 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M115 NET_3564 NET_92 VSS VDD33 P33 l=0.300u w=5.100u
M116 PAD NET_53 NET_5931 NET_1364 P33 l=0.300u w=30.000u
M117 NET_5931 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_3510 NET_5929 NET_1364 P33 l=0.300u w=30.000u
M119 NET_5929 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M120 PAD NET_53 NET_5936 NET_1364 P33 l=0.300u w=30.000u
M121 NET_5936 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M122 VDD33 NET_3510 NET_5934 NET_1364 P33 l=0.300u w=30.000u
M123 NET_5934 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M124 VDD NET_92 NET_108 VDD P33 l=0.300u w=5.000u
M125 VDD NET_92 NET_108 VDD P33 l=0.300u w=5.000u
M126 NET_108 NET_92 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_92 NET_108 VDD P33 l=0.300u w=5.000u
M128 VDD33 NET_47 NET_95 VDD33 P33 l=0.300u w=5.000u
M129 PAD NET_53 NET_5927 NET_1364 P33 l=0.300u w=30.000u
M130 NET_5927 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M131 NET_5925 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M132 NET_5925 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M133 PAD NET_53 NET_5917 NET_1364 P33 l=0.300u w=30.000u
M134 PAD NET_53 NET_5932 NET_1364 P33 l=0.300u w=30.000u
M135 NET_5932 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M136 NET_5926 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M137 NET_5926 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M138 PAD NET_53 NET_5921 NET_1364 P33 l=0.300u w=30.000u
M139 VDD33 VSS NET_3510 VDD33 P33 l=0.300u w=5.000u
M140 NET_47 NET_87 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_47 NET_87 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_3510 NET_5915 NET_1364 P33 l=0.300u w=30.000u
M143 NET_5915 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M144 NET_5907 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M145 NET_5907 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M146 VDD33 NET_3510 NET_5919 NET_1364 P33 l=0.300u w=30.000u
M147 NET_5919 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M148 NET_5912 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M149 NET_5912 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M150 VDD33 NET_52 NET_50 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_50 NET_52 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_3510 NET_5905 NET_1364 P33 l=0.300u w=30.000u
M153 NET_5905 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M154 PAD NET_53 NET_5903 NET_1364 P33 l=0.300u w=30.000u
M155 NET_5903 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M156 NET_5894 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M157 VDD33 NET_3510 NET_5910 NET_1364 P33 l=0.300u w=30.000u
M158 NET_5910 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M159 PAD NET_53 NET_5908 NET_1364 P33 l=0.300u w=30.000u
M160 NET_5908 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M161 NET_5898 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M162 VDD33 NET_56 NET_57 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_57 NET_56 VDD33 P33 l=0.300u w=5.000u
M164 NET_64 NET_56 VDD33 VDD33 P33 l=0.300u w=5.000u
M165 NET_64 NET_56 VDD33 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_56 NET_64 VDD33 P33 l=0.300u w=5.000u
M167 PAD NET_53 NET_5892 NET_1364 P33 l=0.300u w=30.000u
M168 NET_5892 NET_64 VDD33 NET_1364 P33 l=0.300u w=30.000u
M169 PAD NET_53 NET_5896 NET_1364 P33 l=0.300u w=30.000u
M170 NET_5896 NET_64 VDD33 NET_1364 P33 l=0.300u w=30.000u
M171 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M172 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M173 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M174 VDD33 NET_45 NET_3564 VDD33 P33 l=0.300u w=5.000u
M175 NET_3564 NET_92 VSS VDD33 P33 l=0.300u w=5.100u
M176 PAD VDD33 NET_53 NET_1364 P33 l=0.350u w=10.000u
M177 NET_5917 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M178 NET_5894 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M179 NET_5921 NET_3510 VDD33 NET_1364 P33 l=0.300u w=30.000u
M180 NET_5898 NET_53 PAD NET_1364 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
R1 PAD NET_45 300.135
.ends PBS2

.subckt PBS16   PAD OEN I C FP
M1 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M3 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M5 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M8 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M9 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M10 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M11 NET_52 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_52 NET_53 NET_51 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M17 NET_56 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_56 VSS N18 l=0.180u w=2.000u
M19 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M20 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M21 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M23 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M24 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M25 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M27 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M30 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M33 NET_5983 OEN NET_56 VDD P18 l=0.180u w=5.000u
M34 NET_5983 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_61 NET_56 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M37 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M38 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M39 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_53 NET_51 VDD P18 l=0.180u w=5.000u
M42 NET_51 NET_53 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_100 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_100 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M77 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M78 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M79 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M80 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M81 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M82 NET_68 NET_51 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M84 NET_69 NET_47 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M86 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_53 NET_77 VSS N33 l=0.350u w=7.440u
M89 NET_77 NET_53 VSS VSS N33 l=0.350u w=7.440u
M90 NET_82 NET_3505 NET_80 VSS N33 l=0.350u w=8.000u
M91 NET_82 NET_79 VSS VSS N33 l=0.350u w=8.000u
M92 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M94 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M95 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M97 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M98 NET_105 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M99 NET_85 NET_105 NET_109 VSS N33 l=0.350u w=8.000u
M100 NET_85 NET_105 VSS VSS N33 l=0.350u w=8.000u
M101 NET_85 NET_109 VDD33 VSS N33 l=0.350u w=0.820u
M102 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M103 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M104 NET_5964 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M105 NET_5964 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M106 NET_5966 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M107 NET_5966 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M108 NET_1364 NET_1364 NET_1364 NET_1364 P33 l=1.070u w=5.000u
M109 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M110 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M111 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M112 PAD NET_80 NET_5957 NET_1364 P33 l=0.300u w=30.000u
M113 NET_5957 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M114 VDD33 NET_3505 NET_5955 NET_1364 P33 l=0.300u w=30.000u
M115 NET_5955 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M116 PAD NET_80 NET_5962 NET_1364 P33 l=0.300u w=30.000u
M117 NET_5962 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_3505 NET_5960 NET_1364 P33 l=0.300u w=30.000u
M119 NET_5960 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M120 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M121 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M122 NET_3547 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M124 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M125 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M126 NET_96 NET_109 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M128 PAD NET_80 NET_5953 NET_1364 P33 l=0.300u w=30.000u
M129 PAD NET_80 NET_5958 NET_1364 P33 l=0.300u w=30.000u
M130 NET_5951 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M131 NET_5951 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M132 PAD NET_80 NET_5943 NET_1364 P33 l=0.300u w=30.000u
M133 NET_5952 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M134 NET_5952 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M135 PAD NET_80 NET_5947 NET_1364 P33 l=0.300u w=30.000u
M136 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M137 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_5953 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M139 NET_5958 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M140 VDD33 NET_65 NET_5941 NET_1364 P33 l=0.300u w=30.000u
M141 NET_5941 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M142 VDD33 NET_65 NET_5945 NET_1364 P33 l=0.300u w=30.000u
M143 NET_5945 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M144 VDD33 NET_83 NET_100 VDD33 P33 l=0.300u w=5.000u
M145 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M146 NET_5933 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M147 NET_5933 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M148 NET_5938 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M149 NET_5938 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M150 VDD33 VSS NET_3505 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_83 NET_104 VDD33 P33 l=0.300u w=5.000u
M152 NET_83 NET_104 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_65 NET_5931 NET_1364 P33 l=0.300u w=30.000u
M154 NET_5931 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M155 PAD NET_80 NET_5929 NET_1364 P33 l=0.300u w=30.000u
M156 VDD33 NET_65 NET_5936 NET_1364 P33 l=0.300u w=30.000u
M157 NET_5936 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M158 PAD NET_80 NET_5934 NET_1364 P33 l=0.300u w=30.000u
M159 VDD33 NET_79 NET_77 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_77 NET_79 VDD33 P33 l=0.300u w=5.000u
M161 NET_5920 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M162 NET_5924 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M163 NET_5929 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M164 NET_5934 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M165 PAD NET_80 NET_5918 NET_1364 P33 l=0.300u w=30.000u
M166 NET_5918 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M167 PAD NET_80 NET_5922 NET_1364 P33 l=0.300u w=30.000u
M168 NET_5922 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M169 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M170 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M171 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M172 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M173 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_68 NET_65 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_68 NET_69 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_69 NET_68 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_45 NET_3547 VDD33 P33 l=0.300u w=5.000u
M178 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M179 NET_5943 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M180 NET_5947 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M181 NET_5920 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M182 NET_5924 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
M184 PAD VDD33 NET_80 NET_1364 P33 l=0.350u w=10.000u
R1 PAD NET_45 300.135
.ends PBS16

.subckt PBS12   PAD OEN I C FP
M1 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M3 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M5 C NET_93 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_93 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M8 VSS NET_96 NET_93 VSS N18 l=0.180u w=2.000u
M9 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M10 VSS NET_51 NET_47 VSS N18 l=0.180u w=4.000u
M11 NET_52 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_52 NET_53 NET_51 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_53 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_56 VSS N18 l=0.180u w=2.000u
M17 NET_56 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_56 VSS N18 l=0.180u w=2.000u
M19 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M20 VSS NET_56 NET_61 VSS N18 l=0.180u w=2.000u
M21 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M23 VDD NET_96 NET_93 VDD P18 l=0.180u w=5.000u
M24 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M25 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M27 C NET_93 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_93 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M30 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_53 VDD P18 l=0.180u w=5.000u
M33 NET_5983 OEN NET_56 VDD P18 l=0.180u w=5.000u
M34 NET_5983 I VDD VDD P18 l=0.180u w=5.000u
M35 NET_61 NET_56 VDD VDD P18 l=0.180u w=5.000u
M36 VDD NET_56 NET_61 VDD P18 l=0.180u w=5.000u
M37 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M38 VDD NET_51 NET_47 VDD P18 l=0.180u w=5.000u
M39 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_51 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_53 NET_51 VDD P18 l=0.180u w=5.000u
M42 NET_51 NET_53 VDD VDD P18 l=0.180u w=5.000u
M43 NET_42 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_32 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_100 NET_30 VSSD N33 l=0.400u w=28.000u
M48 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M50 NET_28 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_44 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_39 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_100 NET_37 VSSD N33 l=0.400u w=28.000u
M56 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M58 NET_35 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_25 NET_26 VSSD N33 l=0.400u w=28.000u
M60 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_25 NET_15 VSSD N33 l=0.400u w=28.000u
M64 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M66 NET_13 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_25 NET_33 VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_25 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_25 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_25 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M77 VSS NET_83 NET_100 VSS N33 l=0.350u w=8.000u
M78 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M79 VSS NET_68 NET_65 VSS N33 l=0.350u w=10.000u
M80 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M81 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M82 NET_68 NET_51 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M84 NET_69 NET_47 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_47 NET_69 VSS N33 l=0.350u w=5.330u
M86 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_79 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_53 NET_77 VSS N33 l=0.350u w=7.440u
M89 NET_77 NET_53 VSS VSS N33 l=0.350u w=7.440u
M90 NET_82 NET_3505 NET_80 VSS N33 l=0.350u w=8.000u
M91 NET_82 NET_79 VSS VSS N33 l=0.350u w=8.000u
M92 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M94 VSS NET_56 NET_83 VSS N33 l=0.350u w=8.000u
M95 NET_104 NET_61 VSS VSS N33 l=0.350u w=8.000u
M96 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M97 NET_45 VDD33 NET_105 VSS N33 l=0.350u w=8.000u
M98 NET_105 VDD33 NET_45 VSS N33 l=0.350u w=8.000u
M99 NET_85 NET_105 NET_109 VSS N33 l=0.350u w=8.000u
M100 NET_85 NET_105 VSS VSS N33 l=0.350u w=8.000u
M101 NET_85 NET_109 VDD33 VSS N33 l=0.350u w=0.820u
M102 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M103 VSS NET_109 NET_96 VSS N33 l=0.350u w=2.000u
M104 NET_5964 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M105 NET_5964 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M106 NET_5966 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M107 NET_5966 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M108 NET_1364 NET_1364 NET_1364 NET_1364 P33 l=1.070u w=5.000u
M109 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M110 VSS NET_109 NET_3547 VDD33 P33 l=0.300u w=5.100u
M111 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M112 PAD NET_80 NET_5957 NET_1364 P33 l=0.300u w=30.000u
M113 NET_5957 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M114 VDD33 NET_3505 NET_5955 NET_1364 P33 l=0.300u w=30.000u
M115 NET_5955 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M116 PAD NET_80 NET_5962 NET_1364 P33 l=0.300u w=30.000u
M117 NET_5962 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_3505 NET_5960 NET_1364 P33 l=0.300u w=30.000u
M119 NET_5960 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M120 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M121 NET_109 NET_105 NET_3547 VDD33 P33 l=0.300u w=5.000u
M122 NET_3547 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M124 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M125 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M126 NET_96 NET_109 VDD VDD P33 l=0.300u w=5.000u
M127 VDD NET_109 NET_96 VDD P33 l=0.300u w=5.000u
M128 PAD NET_80 NET_5953 NET_1364 P33 l=0.300u w=30.000u
M129 PAD NET_80 NET_5958 NET_1364 P33 l=0.300u w=30.000u
M130 NET_5951 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M131 NET_5951 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M132 PAD NET_80 NET_5943 NET_1364 P33 l=0.300u w=30.000u
M133 NET_5952 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M134 NET_5952 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M135 PAD NET_80 NET_5947 NET_1364 P33 l=0.300u w=30.000u
M136 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M137 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M138 NET_5953 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M139 NET_5958 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M140 VDD33 NET_65 NET_5941 NET_1364 P33 l=0.300u w=30.000u
M141 NET_5941 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M142 VDD33 NET_65 NET_5945 NET_1364 P33 l=0.300u w=30.000u
M143 NET_5945 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M144 VDD33 NET_83 NET_100 VDD33 P33 l=0.300u w=5.000u
M145 NET_100 NET_83 VDD33 VDD33 P33 l=0.300u w=5.000u
M146 NET_5933 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M147 NET_5933 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M148 NET_5938 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M149 NET_5938 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M150 VDD33 VSS NET_3505 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_83 NET_104 VDD33 P33 l=0.300u w=5.000u
M152 NET_83 NET_104 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_65 NET_5931 NET_1364 P33 l=0.300u w=30.000u
M154 NET_5931 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M155 PAD NET_80 NET_5929 NET_1364 P33 l=0.300u w=30.000u
M156 VDD33 NET_65 NET_5936 NET_1364 P33 l=0.300u w=30.000u
M157 NET_5936 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M158 PAD NET_80 NET_5934 NET_1364 P33 l=0.300u w=30.000u
M159 VDD33 NET_79 NET_77 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_77 NET_79 VDD33 P33 l=0.300u w=5.000u
M161 NET_5920 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M162 NET_5924 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M163 NET_5929 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M164 NET_5934 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M165 PAD NET_80 NET_5918 NET_1364 P33 l=0.300u w=30.000u
M166 NET_5918 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M167 PAD NET_80 NET_5922 NET_1364 P33 l=0.300u w=30.000u
M168 NET_5922 NET_65 VDD33 NET_1364 P33 l=0.300u w=30.000u
M169 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M170 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M171 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M172 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M173 NET_65 NET_68 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_68 NET_65 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_68 NET_69 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_69 NET_68 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_45 NET_3547 VDD33 P33 l=0.300u w=5.000u
M178 NET_3547 NET_109 VSS VDD33 P33 l=0.300u w=5.100u
M179 NET_5943 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M180 NET_5947 NET_3505 VDD33 NET_1364 P33 l=0.300u w=30.000u
M181 NET_5920 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M182 NET_5924 NET_80 PAD NET_1364 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
M184 PAD VDD33 NET_80 NET_1364 P33 l=0.350u w=10.000u
R1 PAD NET_45 300.135
.ends PBS12

.subckt PBDL16   PAD OEN I C FP
M1 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M3 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M5 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_106 NET_103 VSS N18 l=0.180u w=2.000u
M8 VSS NET_106 NET_103 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_106 NET_103 VDD P18 l=0.180u w=5.000u
M23 VDD NET_106 NET_103 VDD P18 l=0.180u w=5.000u
M24 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M25 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M27 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 NET_5989 OEN NET_74 VDD P18 l=0.180u w=5.000u
M33 NET_5989 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M36 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M37 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M38 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M41 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M43 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_89 NET_29 VSSD N33 l=0.400u w=28.000u
M47 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M48 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M49 NET_27 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_38 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_89 NET_36 VSSD N33 l=0.400u w=28.000u
M54 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M56 NET_34 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M57 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M60 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M61 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M62 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M63 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M68 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M70 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_41 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M74 NET_43 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_88 NET_46 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_45 NET_89 VSS N33 l=0.350u w=8.000u
M78 VSS NET_45 NET_89 VSS N33 l=0.350u w=8.000u
M79 NET_48 NET_49 VSS VSS N33 l=0.350u w=3.400u
M80 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M81 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M82 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M84 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M86 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M89 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M90 NET_63 NET_3499 NET_61 VSS N33 l=0.350u w=8.000u
M91 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M92 NET_88 NET_46 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M94 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M95 NET_44 VDD33 NET_83 VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_83 VSS N33 l=0.350u w=8.000u
M97 NET_83 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M98 VSS NET_83 NET_92 VSS N33 l=0.350u w=8.000u
M99 NET_83 VDD33 VSS VSS N33 l=4.550u w=0.800u
M100 VSS NET_92 NET_106 VSS N33 l=0.350u w=2.000u
M101 VSS NET_92 NET_106 VSS N33 l=0.350u w=2.000u
M102 NET_5957 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M103 NET_5957 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M104 NET_5959 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M105 NET_5959 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M106 NET_1362 NET_1362 NET_1362 NET_1362 P33 l=1.070u w=5.000u
M107 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M108 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M109 NET_106 NET_92 VDD VDD P33 l=0.300u w=5.000u
M110 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M111 PAD NET_61 NET_5950 NET_1362 P33 l=0.300u w=30.000u
M112 VDD33 NET_3499 NET_5950 NET_1362 P33 l=0.300u w=30.000u
M113 VDD33 NET_3499 NET_5948 NET_1362 P33 l=0.300u w=30.000u
M114 NET_5948 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M115 PAD NET_61 NET_5955 NET_1362 P33 l=0.300u w=30.000u
M116 VDD33 NET_3499 NET_5955 NET_1362 P33 l=0.300u w=30.000u
M117 VDD33 NET_3499 NET_5953 NET_1362 P33 l=0.300u w=30.000u
M118 NET_5953 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M119 NET_92 NET_83 NET_3546 VDD33 P33 l=0.300u w=5.000u
M120 NET_92 NET_83 NET_3546 VDD33 P33 l=0.300u w=5.000u
M121 NET_92 NET_83 NET_3546 VDD33 P33 l=0.300u w=5.000u
M122 NET_92 NET_83 NET_3546 VDD33 P33 l=0.300u w=5.000u
M123 NET_3546 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_44 NET_3546 VDD33 P33 l=0.300u w=5.000u
M125 NET_3546 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M127 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M128 NET_106 NET_92 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M130 PAD NET_61 NET_5946 NET_1362 P33 l=0.300u w=30.000u
M131 PAD NET_61 NET_5951 NET_1362 P33 l=0.300u w=30.000u
M132 NET_5940 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M133 NET_5940 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M134 PAD NET_61 NET_5938 NET_1362 P33 l=0.300u w=30.000u
M135 NET_5945 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M136 NET_5945 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M137 PAD NET_61 NET_5943 NET_1362 P33 l=0.300u w=30.000u
M138 NET_89 NET_45 VDD33 VDD33 P33 l=0.300u w=3.600u
M139 NET_5946 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M140 NET_5951 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M141 VDD33 NET_48 NET_5936 NET_1362 P33 l=0.300u w=30.000u
M142 NET_5936 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M143 VDD33 NET_48 NET_5941 NET_1362 P33 l=0.300u w=30.000u
M144 NET_5941 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M145 NET_5926 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M146 NET_5926 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M147 NET_5931 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M148 NET_5931 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M149 VDD33 VSS NET_3499 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_45 NET_88 VDD33 P33 l=0.300u w=5.000u
M151 NET_45 NET_88 VDD33 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_48 NET_5924 NET_1362 P33 l=0.300u w=30.000u
M153 NET_5924 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M154 PAD NET_61 NET_5922 NET_1362 P33 l=0.300u w=30.000u
M155 VDD33 NET_48 NET_5929 NET_1362 P33 l=0.300u w=30.000u
M156 NET_5929 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M157 PAD NET_61 NET_5927 NET_1362 P33 l=0.300u w=30.000u
M158 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M159 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M160 NET_5913 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M161 NET_5917 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M162 NET_5922 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M163 NET_5927 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M164 PAD NET_61 NET_5911 NET_1362 P33 l=0.300u w=30.000u
M165 NET_5911 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M166 PAD NET_61 NET_5915 NET_1362 P33 l=0.300u w=30.000u
M167 NET_5915 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M168 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M169 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M170 VDD33 PAD NET_1362 NET_1362 P33 l=0.350u w=5.000u
M171 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M173 NET_48 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_44 NET_3546 VDD33 P33 l=0.300u w=5.000u
M178 NET_5938 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M179 NET_5943 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M180 NET_5913 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M181 NET_5917 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M182 PAD VDD33 NET_61 NET_1362 P33 l=0.350u w=10.000u
M183 PAD VDD33 NET_1362 NET_1362 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBDL16

.subckt PBDL8   PAD OEN I C FP
M1 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M3 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M5 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_106 NET_103 VSS N18 l=0.180u w=2.000u
M8 VSS NET_106 NET_103 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_106 NET_103 VDD P18 l=0.180u w=5.000u
M23 VDD NET_106 NET_103 VDD P18 l=0.180u w=5.000u
M24 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M25 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M27 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 NET_5999 OEN NET_74 VDD P18 l=0.180u w=5.000u
M33 NET_5999 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M36 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M37 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M38 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M41 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M43 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M47 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M48 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M49 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_38 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M54 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M56 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M57 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M60 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M61 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M62 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M63 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M68 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M70 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_41 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M74 NET_43 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_88 NET_46 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_45 NET_89 VSS N33 l=0.350u w=8.000u
M78 VSS NET_45 NET_89 VSS N33 l=0.350u w=8.000u
M79 NET_48 NET_49 VSS VSS N33 l=0.350u w=4.600u
M80 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M81 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M82 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M84 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M86 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M89 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M90 NET_63 NET_3499 NET_61 VSS N33 l=0.350u w=8.000u
M91 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M92 NET_88 NET_46 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M94 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M95 NET_44 VDD33 NET_83 VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_83 VSS N33 l=0.350u w=8.000u
M97 NET_83 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M98 VSS NET_83 NET_92 VSS N33 l=0.350u w=8.000u
M99 NET_83 VDD33 VSS VSS N33 l=4.550u w=0.800u
M100 VSS NET_92 NET_106 VSS N33 l=0.350u w=2.000u
M101 VSS NET_92 NET_106 VSS N33 l=0.350u w=2.000u
M102 NET_5967 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M103 NET_5967 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M104 NET_5969 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M105 NET_5969 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M106 NET_1362 NET_1362 NET_1362 NET_1362 P33 l=1.070u w=5.000u
M107 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M108 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M109 NET_106 NET_92 VDD VDD P33 l=0.300u w=5.000u
M110 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M111 PAD NET_61 NET_5960 NET_1362 P33 l=0.300u w=30.000u
M112 VDD33 NET_3499 NET_5960 NET_1362 P33 l=0.300u w=30.000u
M113 VDD33 NET_3499 NET_5958 NET_1362 P33 l=0.300u w=30.000u
M114 NET_5958 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M115 PAD NET_61 NET_5965 NET_1362 P33 l=0.300u w=30.000u
M116 VDD33 NET_3499 NET_5965 NET_1362 P33 l=0.300u w=30.000u
M117 VDD33 NET_3499 NET_5963 NET_1362 P33 l=0.300u w=30.000u
M118 NET_5963 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M119 NET_92 NET_83 NET_3548 VDD33 P33 l=0.300u w=5.000u
M120 NET_92 NET_83 NET_3548 VDD33 P33 l=0.300u w=5.000u
M121 NET_92 NET_83 NET_3548 VDD33 P33 l=0.300u w=5.000u
M122 NET_92 NET_83 NET_3548 VDD33 P33 l=0.300u w=5.000u
M123 NET_3548 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_44 NET_3548 VDD33 P33 l=0.300u w=5.000u
M125 NET_3548 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M127 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M128 NET_106 NET_92 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M130 PAD NET_61 NET_5956 NET_1362 P33 l=0.300u w=30.000u
M131 PAD NET_61 NET_5961 NET_1362 P33 l=0.300u w=30.000u
M132 NET_5950 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M133 NET_5950 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M134 PAD NET_61 NET_5948 NET_1362 P33 l=0.300u w=30.000u
M135 NET_5955 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M136 NET_5955 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M137 PAD NET_61 NET_5953 NET_1362 P33 l=0.300u w=30.000u
M138 NET_89 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M139 NET_5956 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M140 NET_5961 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M141 VDD33 NET_3499 NET_5946 NET_1362 P33 l=0.300u w=30.000u
M142 NET_5946 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M143 VDD33 NET_3499 NET_5951 NET_1362 P33 l=0.300u w=30.000u
M144 NET_5951 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M145 NET_5936 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M146 NET_5936 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M147 NET_5941 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M148 NET_5941 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M149 VDD33 VSS NET_3499 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_45 NET_88 VDD33 P33 l=0.300u w=5.000u
M151 NET_45 NET_88 VDD33 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_48 NET_5934 NET_1362 P33 l=0.300u w=30.000u
M153 NET_5934 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M154 PAD NET_61 NET_5932 NET_1362 P33 l=0.300u w=30.000u
M155 VDD33 NET_48 NET_5939 NET_1362 P33 l=0.300u w=30.000u
M156 NET_5939 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M157 PAD NET_61 NET_5937 NET_1362 P33 l=0.300u w=30.000u
M158 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M159 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M160 NET_5923 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M161 NET_5927 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M162 NET_5932 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M163 NET_5937 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M164 PAD NET_61 NET_5921 NET_1362 P33 l=0.300u w=30.000u
M165 NET_5921 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M166 PAD NET_61 NET_5925 NET_1362 P33 l=0.300u w=30.000u
M167 NET_5925 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M168 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M169 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M170 VDD33 PAD NET_1362 NET_1362 P33 l=0.350u w=5.000u
M171 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M173 NET_48 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_44 NET_3548 VDD33 P33 l=0.300u w=5.000u
M178 NET_5948 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M179 NET_5953 NET_3499 VDD33 NET_1362 P33 l=0.300u w=30.000u
M180 NET_5923 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M181 NET_5927 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M182 PAD VDD33 NET_61 NET_1362 P33 l=0.350u w=10.000u
M183 PAD VDD33 NET_1362 NET_1362 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBDL8

.subckt PBDL24   PAD OEN I C FP
M1 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M3 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M5 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_106 NET_103 VSS N18 l=0.180u w=2.000u
M8 VSS NET_106 NET_103 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_46 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_46 VSS N18 l=0.180u w=2.000u
M21 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_106 NET_103 VDD P18 l=0.180u w=5.000u
M23 VDD NET_106 NET_103 VDD P18 l=0.180u w=5.000u
M24 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M25 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M27 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 NET_5997 OEN NET_74 VDD P18 l=0.180u w=5.000u
M33 NET_5997 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M36 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M37 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M38 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M41 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_74 NET_46 VDD P18 l=0.180u w=5.000u
M43 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_89 NET_29 VSSD N33 l=0.400u w=28.000u
M47 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M48 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M49 NET_27 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_38 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_89 NET_36 VSSD N33 l=0.400u w=28.000u
M54 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M56 NET_34 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M57 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_16 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M60 VSSD NET_89 NET_14 VSSD N33 l=0.400u w=28.000u
M61 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M62 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M63 NET_12 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M64 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M68 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M70 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_41 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_89 NET_25 VSSD N33 l=0.400u w=28.000u
M74 NET_43 NET_89 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_88 NET_46 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_45 NET_89 VSS N33 l=0.350u w=8.000u
M78 VSS NET_45 NET_89 VSS N33 l=0.350u w=8.000u
M79 NET_48 NET_49 VSS VSS N33 l=0.350u w=4.400u
M80 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M81 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M82 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M84 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M86 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M89 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M90 NET_63 NET_3499 NET_61 VSS N33 l=0.350u w=8.000u
M91 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M92 NET_88 NET_46 VSS VSS N33 l=0.350u w=8.000u
M93 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M94 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M95 NET_44 VDD33 NET_83 VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_83 VSS N33 l=0.350u w=8.000u
M97 NET_83 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M98 VSS NET_83 NET_92 VSS N33 l=0.350u w=8.000u
M99 NET_83 VDD33 VSS VSS N33 l=4.550u w=0.800u
M100 VSS NET_92 NET_106 VSS N33 l=0.350u w=2.000u
M101 VSS NET_92 NET_106 VSS N33 l=0.350u w=2.000u
M102 NET_5965 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M103 NET_5965 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M104 NET_5967 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M105 NET_5967 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M106 NET_1362 NET_1362 NET_1362 NET_1362 P33 l=1.070u w=5.000u
M107 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M108 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M109 NET_106 NET_92 VDD VDD P33 l=0.300u w=5.000u
M110 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M111 PAD NET_61 NET_5958 NET_1362 P33 l=0.300u w=30.000u
M112 VDD33 NET_48 NET_5958 NET_1362 P33 l=0.300u w=30.000u
M113 VDD33 NET_48 NET_5956 NET_1362 P33 l=0.300u w=30.000u
M114 NET_5956 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M115 PAD NET_61 NET_5963 NET_1362 P33 l=0.300u w=30.000u
M116 VDD33 NET_48 NET_5963 NET_1362 P33 l=0.300u w=30.000u
M117 VDD33 NET_48 NET_5961 NET_1362 P33 l=0.300u w=30.000u
M118 NET_5961 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M119 NET_92 NET_83 NET_3546 VDD33 P33 l=0.300u w=5.000u
M120 NET_92 NET_83 NET_3546 VDD33 P33 l=0.300u w=5.000u
M121 NET_92 NET_83 NET_3546 VDD33 P33 l=0.300u w=5.000u
M122 NET_92 NET_83 NET_3546 VDD33 P33 l=0.300u w=5.000u
M123 NET_3546 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_44 NET_3546 VDD33 P33 l=0.300u w=5.000u
M125 NET_3546 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M127 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M128 NET_106 NET_92 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_92 NET_106 VDD P33 l=0.300u w=5.000u
M130 PAD NET_61 NET_5954 NET_1362 P33 l=0.300u w=30.000u
M131 PAD NET_61 NET_5959 NET_1362 P33 l=0.300u w=30.000u
M132 NET_5948 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M133 NET_5948 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M134 PAD NET_61 NET_5946 NET_1362 P33 l=0.300u w=30.000u
M135 NET_5953 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M136 NET_5953 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M137 PAD NET_61 NET_5951 NET_1362 P33 l=0.300u w=30.000u
M138 VDD33 NET_45 NET_89 VDD33 P33 l=0.300u w=4.600u
M139 NET_5954 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M140 NET_5959 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M141 VDD33 NET_48 NET_5944 NET_1362 P33 l=0.300u w=30.000u
M142 NET_5944 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M143 VDD33 NET_48 NET_5949 NET_1362 P33 l=0.300u w=30.000u
M144 NET_5949 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M145 NET_5934 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M146 NET_5934 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M147 NET_5939 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M148 NET_5939 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M149 VDD33 VSS NET_3499 VDD33 P33 l=0.300u w=5.000u
M150 VDD33 NET_45 NET_88 VDD33 P33 l=0.300u w=5.000u
M151 NET_45 NET_88 VDD33 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_48 NET_5932 NET_1362 P33 l=0.300u w=30.000u
M153 NET_5932 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M154 PAD NET_61 NET_5930 NET_1362 P33 l=0.300u w=30.000u
M155 VDD33 NET_48 NET_5937 NET_1362 P33 l=0.300u w=30.000u
M156 NET_5937 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M157 PAD NET_61 NET_5935 NET_1362 P33 l=0.300u w=30.000u
M158 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M159 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M160 NET_5921 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M161 NET_5925 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M162 NET_5930 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M163 NET_5935 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M164 PAD NET_61 NET_5919 NET_1362 P33 l=0.300u w=30.000u
M165 NET_5919 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M166 PAD NET_61 NET_5923 NET_1362 P33 l=0.300u w=30.000u
M167 NET_5923 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M168 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M169 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M170 VDD33 PAD NET_1362 NET_1362 P33 l=0.350u w=5.000u
M171 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M173 NET_48 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_44 NET_3546 VDD33 P33 l=0.300u w=5.000u
M178 NET_5946 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M179 NET_5951 NET_48 VDD33 NET_1362 P33 l=0.300u w=30.000u
M180 NET_5921 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M181 NET_5925 NET_61 PAD NET_1362 P33 l=0.300u w=30.000u
M182 PAD VDD33 NET_61 NET_1362 P33 l=0.350u w=10.000u
M183 PAD VDD33 NET_1362 NET_1362 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBDL24

.subckt PBDL12   PAD OEN I C FP
M1 VSS NET_107 NET_84 VSS N18 l=0.180u w=2.000u
M2 VSS NET_107 NET_84 VSS N18 l=0.180u w=2.000u
M3 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M5 C NET_84 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M7 C NET_84 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_84 VDD P18 l=0.180u w=5.000u
M23 VDD NET_107 NET_84 VDD P18 l=0.180u w=5.000u
M24 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M25 C NET_84 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M27 C NET_84 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 NET_6022 OEN NET_74 VDD P18 l=0.180u w=5.000u
M33 NET_6022 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M36 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M37 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M38 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M41 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_93 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_93 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M62 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M63 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M64 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M65 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M70 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M72 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M74 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_92 NET_10 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_45 NET_93 VSS N33 l=0.350u w=8.000u
M78 VSS NET_45 NET_93 VSS N33 l=0.350u w=8.000u
M79 VSS NET_49 NET_46 VSS N33 l=0.350u w=5.000u
M80 VSS NET_49 NET_46 VSS N33 l=0.350u w=5.000u
M81 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M82 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M83 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M84 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M85 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M86 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M87 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M88 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M89 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M90 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M91 NET_63 NET_3500 NET_61 VSS N33 l=0.350u w=8.000u
M92 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M93 NET_92 NET_10 VSS VSS N33 l=0.350u w=8.000u
M94 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M95 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_87 VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_87 VSS N33 l=0.350u w=8.000u
M98 NET_87 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M99 VSS NET_87 NET_96 VSS N33 l=0.350u w=8.000u
M100 NET_87 VDD33 VSS VSS N33 l=4.550u w=0.800u
M101 VSS NET_96 NET_107 VSS N33 l=0.350u w=2.000u
M102 VSS NET_96 NET_107 VSS N33 l=0.350u w=2.000u
M103 NET_5990 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M104 NET_5990 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M105 NET_5992 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M106 NET_5992 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M107 NET_1363 NET_1363 NET_1363 NET_1363 P33 l=1.070u w=5.000u
M108 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M109 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M110 NET_107 NET_96 VDD VDD P33 l=0.300u w=5.000u
M111 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M112 PAD NET_61 NET_5983 NET_1363 P33 l=0.300u w=30.000u
M113 VDD33 NET_3500 NET_5983 NET_1363 P33 l=0.300u w=30.000u
M114 VDD33 NET_3500 NET_5981 NET_1363 P33 l=0.300u w=30.000u
M115 NET_5981 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M116 PAD NET_61 NET_5988 NET_1363 P33 l=0.300u w=30.000u
M117 VDD33 NET_3500 NET_5988 NET_1363 P33 l=0.300u w=30.000u
M118 VDD33 NET_3500 NET_5986 NET_1363 P33 l=0.300u w=30.000u
M119 NET_5986 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M120 NET_96 NET_87 NET_3550 VDD33 P33 l=0.300u w=5.000u
M121 NET_96 NET_87 NET_3550 VDD33 P33 l=0.300u w=5.000u
M122 NET_96 NET_87 NET_3550 VDD33 P33 l=0.300u w=5.000u
M123 NET_96 NET_87 NET_3550 VDD33 P33 l=0.300u w=5.000u
M124 NET_3550 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 VDD33 NET_44 NET_3550 VDD33 P33 l=0.300u w=5.000u
M126 NET_3550 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M127 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M128 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M129 NET_107 NET_96 VDD VDD P33 l=0.300u w=5.000u
M130 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M131 PAD NET_61 NET_5979 NET_1363 P33 l=0.300u w=30.000u
M132 PAD NET_61 NET_5984 NET_1363 P33 l=0.300u w=30.000u
M133 NET_5973 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M134 NET_5973 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M135 PAD NET_61 NET_5971 NET_1363 P33 l=0.300u w=30.000u
M136 NET_5978 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M137 NET_5978 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M138 PAD NET_61 NET_5976 NET_1363 P33 l=0.300u w=30.000u
M139 VDD33 NET_45 NET_93 VDD33 P33 l=0.300u w=4.800u
M140 VDD33 NET_45 NET_93 VDD33 P33 l=0.300u w=4.800u
M141 NET_5979 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M142 NET_5984 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M143 VDD33 NET_46 NET_5969 NET_1363 P33 l=0.300u w=30.000u
M144 NET_5969 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M145 VDD33 NET_46 NET_5974 NET_1363 P33 l=0.300u w=30.000u
M146 NET_5974 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M147 NET_5959 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M148 NET_5959 NET_46 VDD33 NET_1363 P33 l=0.300u w=30.000u
M149 NET_5964 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M150 NET_5964 NET_46 VDD33 NET_1363 P33 l=0.300u w=30.000u
M151 VDD33 VSS NET_3500 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_45 NET_92 VDD33 P33 l=0.300u w=5.000u
M153 NET_45 NET_92 VDD33 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_46 NET_5957 NET_1363 P33 l=0.300u w=30.000u
M155 NET_5957 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M156 PAD NET_61 NET_5955 NET_1363 P33 l=0.300u w=30.000u
M157 VDD33 NET_46 NET_5962 NET_1363 P33 l=0.300u w=30.000u
M158 NET_5962 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M159 PAD NET_61 NET_5960 NET_1363 P33 l=0.300u w=30.000u
M160 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M162 NET_5946 NET_46 VDD33 NET_1363 P33 l=0.300u w=30.000u
M163 NET_5950 NET_46 VDD33 NET_1363 P33 l=0.300u w=30.000u
M164 NET_5955 NET_46 VDD33 NET_1363 P33 l=0.300u w=30.000u
M165 NET_5960 NET_46 VDD33 NET_1363 P33 l=0.300u w=30.000u
M166 PAD NET_61 NET_5944 NET_1363 P33 l=0.300u w=30.000u
M167 NET_5944 NET_46 VDD33 NET_1363 P33 l=0.300u w=30.000u
M168 PAD NET_61 NET_5948 NET_1363 P33 l=0.300u w=30.000u
M169 NET_5948 NET_46 VDD33 NET_1363 P33 l=0.300u w=30.000u
M170 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M171 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M172 VDD33 PAD NET_1363 NET_1363 P33 l=0.350u w=5.000u
M173 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M175 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_44 NET_3550 VDD33 P33 l=0.300u w=5.000u
M180 NET_5971 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M181 NET_5976 NET_3500 VDD33 NET_1363 P33 l=0.300u w=30.000u
M182 NET_5946 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M183 NET_5950 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_61 NET_1363 P33 l=0.350u w=10.000u
M185 PAD VDD33 NET_1363 NET_1363 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBDL12

.subckt PBD8   PAD I OEN C FP
M1 VSS NET_107 NET_84 VSS N18 l=0.180u w=2.000u
M2 VSS NET_107 NET_84 VSS N18 l=0.180u w=2.000u
M3 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M5 C NET_84 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M7 C NET_84 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_51 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_51 VSS N18 l=0.180u w=2.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_51 VSS N18 l=0.180u w=2.000u
M13 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M14 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M15 NET_75 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_75 NET_76 NET_74 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_51 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_51 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_84 VDD P18 l=0.180u w=5.000u
M23 VDD NET_107 NET_84 VDD P18 l=0.180u w=5.000u
M24 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M25 C NET_84 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M27 C NET_84 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M32 NET_6045 OEN NET_51 VDD P18 l=0.180u w=5.000u
M33 NET_6045 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M35 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M36 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M37 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M38 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_76 NET_74 VDD P18 l=0.180u w=5.000u
M41 NET_74 NET_76 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M43 NET_92 NET_10 VSS VSS N33 l=0.350u w=8.000u
M44 VSS NET_45 NET_93 VSS N33 l=0.350u w=8.000u
M45 VSS NET_45 NET_93 VSS N33 l=0.350u w=8.000u
M46 NET_50 OEN VSS VSS N33 l=0.350u w=7.440u
M47 NET_50 OEN VSS VSS N33 l=0.350u w=7.440u
M48 VSS NET_76 NET_48 VSS N33 l=0.350u w=7.440u
M49 NET_48 NET_76 VSS VSS N33 l=0.350u w=7.440u
M50 VSS NET_59 NET_56 VSS N33 l=0.350u w=10.000u
M51 VSS NET_59 NET_56 VSS N33 l=0.350u w=10.000u
M52 VSS NET_74 NET_59 VSS N33 l=0.350u w=5.330u
M53 VSS NET_74 NET_59 VSS N33 l=0.350u w=5.330u
M54 NET_59 NET_74 VSS VSS N33 l=0.350u w=5.330u
M55 VSS NET_70 NET_60 VSS N33 l=0.350u w=5.330u
M56 NET_60 NET_70 VSS VSS N33 l=0.350u w=5.330u
M57 VSS NET_70 NET_60 VSS N33 l=0.350u w=5.330u
M58 NET_68 NET_3504 NET_66 VSS N33 l=0.350u w=8.000u
M59 NET_68 NET_50 VSS VSS N33 l=0.350u w=8.000u
M60 NET_92 NET_10 VSS VSS N33 l=0.350u w=8.000u
M61 VSS NET_51 NET_45 VSS N33 l=0.350u w=8.000u
M62 VSS NET_51 NET_45 VSS N33 l=0.350u w=8.000u
M63 NET_44 VDD33 NET_87 VSS N33 l=0.350u w=8.000u
M64 NET_44 VDD33 NET_87 VSS N33 l=0.350u w=8.000u
M65 NET_87 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M66 VSS NET_87 NET_96 VSS N33 l=0.350u w=8.000u
M67 NET_87 VDD33 VSS VSS N33 l=4.550u w=0.800u
M68 VSS NET_96 NET_107 VSS N33 l=0.350u w=2.000u
M69 VSS NET_96 NET_107 VSS N33 l=0.350u w=2.000u
M70 NET_41 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M73 NET_31 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M74 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M75 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M76 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M77 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M78 NET_43 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M80 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M81 NET_38 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M82 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M83 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M84 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M85 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M86 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M87 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M88 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M89 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M90 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M91 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M92 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M93 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M94 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M95 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M96 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M97 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M98 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M99 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M100 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M101 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M102 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M103 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M104 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M105 NET_107 NET_96 VDD VDD P33 l=0.300u w=5.000u
M106 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M107 NET_6014 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M108 NET_6014 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M109 NET_6016 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M110 NET_6016 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M111 NET_1363 NET_1363 NET_1363 NET_1363 P33 l=1.070u w=5.000u
M112 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M113 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M114 NET_107 NET_96 VDD VDD P33 l=0.300u w=5.000u
M115 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M116 PAD NET_66 NET_6007 NET_1363 P33 l=0.300u w=30.000u
M117 VDD33 NET_3504 NET_6007 NET_1363 P33 l=0.300u w=30.000u
M118 VDD33 NET_3504 NET_6005 NET_1363 P33 l=0.300u w=30.000u
M119 NET_6005 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M120 PAD NET_66 NET_6012 NET_1363 P33 l=0.300u w=30.000u
M121 VDD33 NET_3504 NET_6012 NET_1363 P33 l=0.300u w=30.000u
M122 VDD33 NET_3504 NET_6010 NET_1363 P33 l=0.300u w=30.000u
M123 NET_6010 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M124 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M125 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M126 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M127 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M128 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M130 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M131 PAD NET_66 NET_6003 NET_1363 P33 l=0.300u w=30.000u
M132 PAD NET_66 NET_6008 NET_1363 P33 l=0.300u w=30.000u
M133 NET_5997 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M134 NET_5997 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M135 PAD NET_66 NET_5995 NET_1363 P33 l=0.300u w=30.000u
M136 NET_6002 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M137 NET_6002 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M138 PAD NET_66 NET_6000 NET_1363 P33 l=0.300u w=30.000u
M139 NET_93 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M140 NET_93 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 NET_6003 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M142 NET_6008 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M143 VDD33 NET_3504 NET_5993 NET_1363 P33 l=0.300u w=30.000u
M144 NET_5993 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M145 VDD33 NET_3504 NET_5998 NET_1363 P33 l=0.300u w=30.000u
M146 NET_5998 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M147 VDD33 NET_45 NET_93 VDD33 P33 l=0.300u w=5.000u
M148 NET_93 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M149 NET_5983 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M150 NET_5983 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M151 NET_5988 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M152 NET_5988 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M153 VDD33 VSS NET_3504 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_45 NET_92 VDD33 P33 l=0.300u w=5.000u
M155 NET_45 NET_92 VDD33 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_56 NET_5981 NET_1363 P33 l=0.300u w=30.000u
M157 NET_5981 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M158 PAD NET_66 NET_5979 NET_1363 P33 l=0.300u w=30.000u
M159 VDD33 NET_56 NET_5986 NET_1363 P33 l=0.300u w=30.000u
M160 NET_5986 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M161 PAD NET_66 NET_5984 NET_1363 P33 l=0.300u w=30.000u
M162 VDD33 NET_50 NET_48 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_48 NET_50 VDD33 P33 l=0.300u w=5.000u
M164 NET_5970 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M165 NET_5974 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M166 NET_5979 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M167 NET_5984 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M168 PAD NET_66 NET_5968 NET_1363 P33 l=0.300u w=30.000u
M169 NET_5968 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M170 PAD NET_66 NET_5972 NET_1363 P33 l=0.300u w=30.000u
M171 NET_5972 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M172 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M173 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M174 VDD33 PAD NET_1363 NET_1363 P33 l=0.350u w=5.000u
M175 NET_56 NET_59 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 NET_56 NET_59 VDD33 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_59 NET_56 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_59 NET_60 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M181 NET_5995 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M182 NET_6000 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M183 NET_5970 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M184 NET_5974 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M185 PAD VDD33 NET_66 NET_1363 P33 l=0.350u w=10.000u
M186 PAD VDD33 NET_1363 NET_1363 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBD8

.subckt PBD4   PAD OEN I C FP
M1 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M3 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M5 C NET_105 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_105 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M8 VSS NET_108 NET_105 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M23 VDD NET_108 NET_105 VDD P18 l=0.180u w=5.000u
M24 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M25 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M27 C NET_105 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_105 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 NET_6029 OEN NET_74 VDD P18 l=0.180u w=5.000u
M33 NET_6029 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M36 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M37 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M38 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M41 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M43 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M44 NET_87 NET_64 VSS VSS N33 l=0.350u w=4.000u
M45 NET_87 NET_64 VSS VSS N33 l=0.350u w=4.000u
M46 VSS NET_64 NET_87 VSS N33 l=0.350u w=4.000u
M47 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M48 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M49 VSS NET_69 NET_48 VSS N33 l=0.350u w=5.330u
M50 VSS NET_69 NET_48 VSS N33 l=0.350u w=5.330u
M51 NET_48 NET_69 VSS VSS N33 l=0.350u w=5.330u
M52 VSS NET_65 NET_49 VSS N33 l=0.350u w=5.330u
M53 NET_49 NET_65 VSS VSS N33 l=0.350u w=5.330u
M54 VSS NET_65 NET_49 VSS N33 l=0.350u w=5.330u
M55 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M56 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M57 VSS NET_71 NET_57 VSS N33 l=0.350u w=7.440u
M58 NET_57 NET_71 VSS VSS N33 l=0.350u w=7.440u
M59 NET_62 NET_3514 NET_60 VSS N33 l=0.350u w=8.000u
M60 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M61 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M62 VSS NET_74 NET_64 VSS N33 l=0.350u w=8.000u
M63 NET_64 NET_74 VSS VSS N33 l=0.350u w=8.000u
M64 NET_44 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M65 NET_44 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M66 NET_90 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M67 VSS NET_90 NET_94 VSS N33 l=0.350u w=8.000u
M68 NET_90 VDD33 VSS VSS N33 l=4.550u w=0.800u
M69 VSS NET_94 NET_108 VSS N33 l=0.350u w=2.000u
M70 VSS NET_94 NET_108 VSS N33 l=0.350u w=2.000u
M71 NET_41 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M72 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M73 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M74 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M76 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M77 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M78 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_43 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M80 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M81 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M82 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M83 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M84 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M85 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M86 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M87 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M88 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M89 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M90 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M91 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M92 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M93 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M94 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M95 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M96 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M97 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M98 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M99 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M100 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M101 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M102 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M103 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M104 VDD NET_94 NET_108 VDD P33 l=0.300u w=5.000u
M105 VDD NET_94 NET_108 VDD P33 l=0.300u w=5.000u
M106 NET_108 NET_94 VDD VDD P33 l=0.300u w=5.000u
M107 VDD NET_94 NET_108 VDD P33 l=0.300u w=5.000u
M108 NET_5999 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M109 NET_5999 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M110 NET_6001 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M111 NET_6001 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M112 NET_1364 NET_1364 NET_1364 NET_1364 P33 l=1.070u w=5.000u
M113 VDD NET_94 NET_108 VDD P33 l=0.300u w=5.000u
M114 VDD NET_94 NET_108 VDD P33 l=0.300u w=5.000u
M115 NET_108 NET_94 VDD VDD P33 l=0.300u w=5.000u
M116 VDD NET_94 NET_108 VDD P33 l=0.300u w=5.000u
M117 PAD NET_60 NET_5992 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_3514 NET_5992 NET_1364 P33 l=0.300u w=30.000u
M119 VDD33 NET_3514 NET_5990 NET_1364 P33 l=0.300u w=30.000u
M120 NET_5990 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M121 PAD NET_60 NET_5997 NET_1364 P33 l=0.300u w=30.000u
M122 VDD33 NET_3514 NET_5997 NET_1364 P33 l=0.300u w=30.000u
M123 VDD33 NET_3514 NET_5995 NET_1364 P33 l=0.300u w=30.000u
M124 NET_5995 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M125 NET_94 NET_90 NET_3549 VDD33 P33 l=0.300u w=5.000u
M126 NET_94 NET_90 NET_3549 VDD33 P33 l=0.300u w=5.000u
M127 NET_94 NET_90 NET_3549 VDD33 P33 l=0.300u w=5.000u
M128 NET_94 NET_90 NET_3549 VDD33 P33 l=0.300u w=5.000u
M129 NET_3549 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M130 VDD33 NET_44 NET_3549 VDD33 P33 l=0.300u w=5.000u
M131 NET_3549 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M132 PAD NET_60 NET_5988 NET_1364 P33 l=0.300u w=30.000u
M133 PAD NET_60 NET_5993 NET_1364 P33 l=0.300u w=30.000u
M134 NET_5982 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M135 NET_5982 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M136 PAD NET_60 NET_5980 NET_1364 P33 l=0.300u w=30.000u
M137 NET_5987 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M138 NET_5987 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M139 PAD NET_60 NET_5985 NET_1364 P33 l=0.300u w=30.000u
M140 NET_87 NET_64 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 NET_87 NET_64 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 NET_5988 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M143 NET_5993 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M144 VDD33 NET_3514 NET_5978 NET_1364 P33 l=0.300u w=30.000u
M145 NET_5978 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M146 VDD33 NET_3514 NET_5983 NET_1364 P33 l=0.300u w=30.000u
M147 NET_5983 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M148 VDD33 NET_64 NET_87 VDD33 P33 l=0.300u w=5.000u
M149 NET_5968 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M150 NET_5968 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M151 NET_5973 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M152 NET_5973 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M153 VDD33 VSS NET_3514 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_64 NET_85 VDD33 P33 l=0.300u w=5.000u
M155 NET_64 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_3514 NET_5966 NET_1364 P33 l=0.300u w=30.000u
M157 NET_5966 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M158 PAD NET_60 NET_5964 NET_1364 P33 l=0.300u w=30.000u
M159 VDD33 NET_3514 NET_5971 NET_1364 P33 l=0.300u w=30.000u
M160 NET_5971 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M161 PAD NET_60 NET_5969 NET_1364 P33 l=0.300u w=30.000u
M162 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M164 NET_5955 NET_45 VDD33 NET_1364 P33 l=0.300u w=30.000u
M165 NET_5959 NET_45 VDD33 NET_1364 P33 l=0.300u w=30.000u
M166 NET_5964 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M167 NET_5969 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M168 PAD NET_60 NET_5953 NET_1364 P33 l=0.300u w=30.000u
M169 NET_5953 NET_45 VDD33 NET_1364 P33 l=0.300u w=30.000u
M170 PAD NET_60 NET_5957 NET_1364 P33 l=0.300u w=30.000u
M171 NET_5957 NET_45 VDD33 NET_1364 P33 l=0.300u w=30.000u
M172 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M173 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M174 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M175 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_44 NET_3549 VDD33 P33 l=0.300u w=5.000u
M180 NET_5980 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M181 NET_5985 NET_3514 VDD33 NET_1364 P33 l=0.300u w=30.000u
M182 NET_5955 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M183 NET_5959 NET_60 PAD NET_1364 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
M185 PAD VDD33 NET_60 NET_1364 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBD4

.subckt PBD24   PAD I OEN C FP
M1 VSS NET_108 NET_84 VSS N18 l=0.180u w=2.000u
M2 VSS NET_108 NET_84 VSS N18 l=0.180u w=2.000u
M3 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M5 C NET_84 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M7 C NET_84 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_50 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_50 VSS N18 l=0.180u w=2.000u
M11 NET_50 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_50 VSS N18 l=0.180u w=2.000u
M13 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M14 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M15 NET_75 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_75 NET_76 NET_74 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_50 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_50 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_108 NET_84 VDD P18 l=0.180u w=5.000u
M23 VDD NET_108 NET_84 VDD P18 l=0.180u w=5.000u
M24 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M25 C NET_84 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M27 C NET_84 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_50 NET_10 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M32 NET_6046 OEN NET_50 VDD P18 l=0.180u w=5.000u
M33 NET_6046 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_50 NET_10 VDD P18 l=0.180u w=5.000u
M35 VDD NET_50 NET_10 VDD P18 l=0.180u w=5.000u
M36 VDD NET_50 NET_10 VDD P18 l=0.180u w=5.000u
M37 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M38 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M39 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_76 NET_74 VDD P18 l=0.180u w=5.000u
M42 NET_74 NET_76 VDD VDD P18 l=0.180u w=5.000u
M43 NET_92 NET_10 VSS VSS N33 l=0.350u w=8.000u
M44 NET_94 NET_69 VSS VSS N33 l=0.350u w=8.000u
M45 NET_94 NET_69 VSS VSS N33 l=0.350u w=8.000u
M46 VSS NET_69 NET_94 VSS N33 l=0.350u w=8.000u
M47 NET_49 OEN VSS VSS N33 l=0.350u w=7.440u
M48 NET_49 OEN VSS VSS N33 l=0.350u w=7.440u
M49 VSS NET_76 NET_47 VSS N33 l=0.350u w=7.440u
M50 NET_47 NET_76 VSS VSS N33 l=0.350u w=7.440u
M51 VSS NET_58 NET_55 VSS N33 l=0.350u w=8.000u
M52 VSS NET_58 NET_55 VSS N33 l=0.350u w=8.000u
M53 VSS NET_74 NET_58 VSS N33 l=0.350u w=5.330u
M54 VSS NET_74 NET_58 VSS N33 l=0.350u w=5.330u
M55 NET_58 NET_74 VSS VSS N33 l=0.350u w=5.330u
M56 VSS NET_70 NET_59 VSS N33 l=0.350u w=5.330u
M57 NET_59 NET_70 VSS VSS N33 l=0.350u w=5.330u
M58 VSS NET_70 NET_59 VSS N33 l=0.350u w=5.330u
M59 NET_67 NET_3502 NET_65 VSS N33 l=0.350u w=8.000u
M60 NET_67 NET_49 VSS VSS N33 l=0.350u w=8.000u
M61 NET_92 NET_10 VSS VSS N33 l=0.350u w=8.000u
M62 VSS NET_50 NET_69 VSS N33 l=0.350u w=8.000u
M63 NET_69 NET_50 VSS VSS N33 l=0.350u w=8.000u
M64 NET_44 VDD33 NET_87 VSS N33 l=0.350u w=8.000u
M65 NET_44 VDD33 NET_87 VSS N33 l=0.350u w=8.000u
M66 NET_87 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M67 VSS NET_87 NET_97 VSS N33 l=0.350u w=8.000u
M68 NET_87 VDD33 VSS VSS N33 l=4.550u w=0.800u
M69 VSS NET_97 NET_108 VSS N33 l=0.350u w=2.000u
M70 VSS NET_97 NET_108 VSS N33 l=0.350u w=2.000u
M71 NET_41 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M72 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M73 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M74 NET_31 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_94 NET_29 VSSD N33 l=0.400u w=28.000u
M76 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M77 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M78 NET_27 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_43 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M80 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M81 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M82 NET_38 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M83 VSSD NET_94 NET_36 VSSD N33 l=0.400u w=28.000u
M84 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M85 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M86 NET_34 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M87 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M88 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M89 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M90 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M91 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M92 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M93 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M94 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M95 VSSD NET_94 NET_32 VSSD N33 l=0.400u w=28.000u
M96 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M97 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M98 NET_22 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M99 VSSD NET_94 NET_20 VSSD N33 l=0.400u w=28.000u
M100 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M101 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M102 NET_18 NET_94 VSSD VSSD N33 l=0.400u w=28.000u
M103 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M104 VDD NET_97 NET_108 VDD P33 l=0.300u w=5.000u
M105 VDD NET_97 NET_108 VDD P33 l=0.300u w=5.000u
M106 NET_108 NET_97 VDD VDD P33 l=0.300u w=5.000u
M107 VDD NET_97 NET_108 VDD P33 l=0.300u w=5.000u
M108 NET_6013 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M109 NET_6013 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M110 NET_6015 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M111 NET_6015 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M112 NET_1364 NET_1364 NET_1364 NET_1364 P33 l=1.070u w=5.000u
M113 VDD NET_97 NET_108 VDD P33 l=0.300u w=5.000u
M114 VDD NET_97 NET_108 VDD P33 l=0.300u w=5.000u
M115 NET_108 NET_97 VDD VDD P33 l=0.300u w=5.000u
M116 VDD NET_97 NET_108 VDD P33 l=0.300u w=5.000u
M117 PAD NET_65 NET_6006 NET_1364 P33 l=0.300u w=30.000u
M118 VDD33 NET_55 NET_6006 NET_1364 P33 l=0.300u w=30.000u
M119 VDD33 NET_55 NET_6004 NET_1364 P33 l=0.300u w=30.000u
M120 NET_6004 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M121 PAD NET_65 NET_6011 NET_1364 P33 l=0.300u w=30.000u
M122 VDD33 NET_55 NET_6011 NET_1364 P33 l=0.300u w=30.000u
M123 VDD33 NET_55 NET_6009 NET_1364 P33 l=0.300u w=30.000u
M124 NET_6009 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M125 NET_97 NET_87 NET_3537 VDD33 P33 l=0.300u w=5.000u
M126 NET_97 NET_87 NET_3537 VDD33 P33 l=0.300u w=5.000u
M127 NET_97 NET_87 NET_3537 VDD33 P33 l=0.300u w=5.000u
M128 NET_97 NET_87 NET_3537 VDD33 P33 l=0.300u w=5.000u
M129 NET_3537 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M130 VDD33 NET_44 NET_3537 VDD33 P33 l=0.300u w=5.000u
M131 NET_3537 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M132 PAD NET_65 NET_6002 NET_1364 P33 l=0.300u w=30.000u
M133 PAD NET_65 NET_6007 NET_1364 P33 l=0.300u w=30.000u
M134 NET_6002 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M135 NET_5996 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M136 NET_5996 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M137 PAD NET_65 NET_5994 NET_1364 P33 l=0.300u w=30.000u
M138 NET_6007 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M139 NET_6001 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M140 NET_6001 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M141 PAD NET_65 NET_5999 NET_1364 P33 l=0.300u w=30.000u
M142 NET_94 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M143 NET_94 NET_69 VDD33 VDD33 P33 l=0.300u w=5.000u
M144 VDD33 NET_55 NET_5992 NET_1364 P33 l=0.300u w=30.000u
M145 NET_5992 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M146 VDD33 NET_55 NET_5997 NET_1364 P33 l=0.300u w=30.000u
M147 NET_5997 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M148 VDD33 NET_69 NET_94 VDD33 P33 l=0.300u w=5.000u
M149 NET_5982 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M150 NET_5982 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M151 NET_5987 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M152 NET_5987 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M153 VDD33 VSS NET_3502 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_69 NET_92 VDD33 P33 l=0.300u w=5.000u
M155 NET_69 NET_92 VDD33 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_55 NET_5980 NET_1364 P33 l=0.300u w=30.000u
M157 NET_5980 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M158 PAD NET_65 NET_5978 NET_1364 P33 l=0.300u w=30.000u
M159 VDD33 NET_55 NET_5985 NET_1364 P33 l=0.300u w=30.000u
M160 NET_5985 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M161 PAD NET_65 NET_5983 NET_1364 P33 l=0.300u w=30.000u
M162 VDD33 NET_49 NET_47 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_47 NET_49 VDD33 P33 l=0.300u w=5.000u
M164 NET_5978 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M165 NET_5969 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M166 NET_5983 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M167 NET_5973 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M168 PAD NET_65 NET_5967 NET_1364 P33 l=0.300u w=30.000u
M169 NET_5967 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M170 PAD NET_65 NET_5971 NET_1364 P33 l=0.300u w=30.000u
M171 NET_5971 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M172 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M173 NET_1364 PAD VDD33 NET_1364 P33 l=0.350u w=5.000u
M174 VDD33 PAD NET_1364 NET_1364 P33 l=0.350u w=5.000u
M175 NET_55 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 NET_55 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_58 NET_55 VDD33 P33 l=0.300u w=5.000u
M178 NET_55 NET_58 VDD33 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_58 NET_55 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_58 NET_59 VDD33 P33 l=0.300u w=5.000u
M181 VDD33 NET_59 NET_58 VDD33 P33 l=0.300u w=5.000u
M182 VDD33 NET_44 NET_3537 VDD33 P33 l=0.300u w=5.000u
M183 NET_5994 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M184 NET_5999 NET_55 VDD33 NET_1364 P33 l=0.300u w=30.000u
M185 NET_5969 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M186 NET_5973 NET_65 PAD NET_1364 P33 l=0.300u w=30.000u
M187 PAD VDD33 NET_65 NET_1364 P33 l=0.350u w=10.000u
M188 PAD VDD33 NET_1364 NET_1364 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBD24

.subckt PBD2   PAD OEN I C FP
M1 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M3 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M5 C NET_104 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_104 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M8 VSS NET_107 NET_104 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M23 VDD NET_107 NET_104 VDD P18 l=0.180u w=5.000u
M24 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M25 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M27 C NET_104 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_104 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M30 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M33 NET_6019 OEN NET_74 VDD P18 l=0.180u w=5.000u
M34 NET_6019 I VDD VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M36 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M37 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M38 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M39 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M42 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M62 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M63 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M64 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M65 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M70 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M72 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M74 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_45 NET_86 VSS N33 l=0.350u w=4.000u
M78 VSS NET_45 NET_86 VSS N33 l=0.350u w=4.000u
M79 VSS NET_49 NET_46 VSS N33 l=0.350u w=4.000u
M80 VSS NET_49 NET_46 VSS N33 l=0.350u w=4.000u
M81 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M82 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M83 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M84 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M85 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M86 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M87 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M88 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M89 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M90 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M91 NET_63 NET_3509 NET_61 VSS N33 l=0.350u w=8.000u
M92 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M93 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M94 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M95 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_89 VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_89 VSS N33 l=0.350u w=8.000u
M98 NET_89 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M99 VSS NET_89 NET_93 VSS N33 l=0.350u w=8.000u
M100 NET_89 VDD33 VSS VSS N33 l=4.550u w=0.800u
M101 VSS NET_93 NET_107 VSS N33 l=0.350u w=2.000u
M102 VSS NET_93 NET_107 VSS N33 l=0.350u w=2.000u
M103 NET_5988 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M104 NET_5988 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M105 NET_5990 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M106 NET_5990 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M107 NET_1363 NET_1363 NET_1363 NET_1363 P33 l=1.070u w=5.000u
M108 VDD NET_93 NET_107 VDD P33 l=0.300u w=5.000u
M109 VDD NET_93 NET_107 VDD P33 l=0.300u w=5.000u
M110 NET_107 NET_93 VDD VDD P33 l=0.300u w=5.000u
M111 VDD NET_93 NET_107 VDD P33 l=0.300u w=5.000u
M112 NET_93 NET_89 NET_3563 VDD33 P33 l=0.300u w=5.000u
M113 NET_93 NET_89 NET_3563 VDD33 P33 l=0.300u w=5.000u
M114 NET_93 NET_89 NET_3563 VDD33 P33 l=0.300u w=5.000u
M115 NET_93 NET_89 NET_3563 VDD33 P33 l=0.300u w=5.000u
M116 NET_3563 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M117 VDD33 NET_44 NET_3563 VDD33 P33 l=0.300u w=5.000u
M118 NET_3563 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M119 PAD NET_61 NET_5981 NET_1363 P33 l=0.300u w=30.000u
M120 VDD33 NET_3509 NET_5981 NET_1363 P33 l=0.300u w=30.000u
M121 VDD33 NET_3509 NET_5979 NET_1363 P33 l=0.300u w=30.000u
M122 NET_5979 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M123 PAD NET_61 NET_5986 NET_1363 P33 l=0.300u w=30.000u
M124 VDD33 NET_3509 NET_5986 NET_1363 P33 l=0.300u w=30.000u
M125 VDD33 NET_3509 NET_5984 NET_1363 P33 l=0.300u w=30.000u
M126 NET_5984 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M127 VDD NET_93 NET_107 VDD P33 l=0.300u w=5.000u
M128 VDD NET_93 NET_107 VDD P33 l=0.300u w=5.000u
M129 NET_107 NET_93 VDD VDD P33 l=0.300u w=5.000u
M130 VDD NET_93 NET_107 VDD P33 l=0.300u w=5.000u
M131 PAD NET_61 NET_5977 NET_1363 P33 l=0.300u w=30.000u
M132 PAD NET_61 NET_5982 NET_1363 P33 l=0.300u w=30.000u
M133 VDD33 NET_45 NET_86 VDD33 P33 l=0.300u w=5.000u
M134 NET_5971 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M135 NET_5971 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M136 PAD NET_61 NET_5969 NET_1363 P33 l=0.300u w=30.000u
M137 NET_5976 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M138 NET_5976 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M139 PAD NET_61 NET_5974 NET_1363 P33 l=0.300u w=30.000u
M140 NET_5977 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M141 NET_5982 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M142 VDD33 NET_3509 NET_5967 NET_1363 P33 l=0.300u w=30.000u
M143 NET_5967 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M144 VDD33 NET_3509 NET_5972 NET_1363 P33 l=0.300u w=30.000u
M145 NET_5972 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M146 VDD33 VSS NET_3509 VDD33 P33 l=0.300u w=5.000u
M147 VDD33 NET_45 NET_85 VDD33 P33 l=0.300u w=5.000u
M148 NET_5957 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M149 NET_5957 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M150 NET_5962 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M151 NET_5962 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M152 NET_45 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_3509 NET_5955 NET_1363 P33 l=0.300u w=30.000u
M156 NET_5955 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M157 PAD NET_61 NET_5953 NET_1363 P33 l=0.300u w=30.000u
M158 VDD33 NET_3509 NET_5960 NET_1363 P33 l=0.300u w=30.000u
M159 NET_5960 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M160 PAD NET_61 NET_5958 NET_1363 P33 l=0.300u w=30.000u
M161 NET_5944 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M162 NET_5948 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M163 NET_5953 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M164 NET_5958 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M165 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M167 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M168 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M170 PAD NET_61 NET_5942 NET_1363 P33 l=0.300u w=30.000u
M171 NET_5942 NET_46 VDD33 NET_1363 P33 l=0.300u w=30.000u
M172 PAD NET_61 NET_5946 NET_1363 P33 l=0.300u w=30.000u
M173 NET_5946 NET_46 VDD33 NET_1363 P33 l=0.300u w=30.000u
M174 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M175 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M176 VDD33 PAD NET_1363 NET_1363 P33 l=0.350u w=5.000u
M177 VDD33 NET_44 NET_3563 VDD33 P33 l=0.300u w=5.000u
M178 NET_5969 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M179 NET_5974 NET_3509 VDD33 NET_1363 P33 l=0.300u w=30.000u
M180 NET_5944 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M181 NET_5948 NET_61 PAD NET_1363 P33 l=0.300u w=30.000u
M182 PAD VDD33 NET_1363 NET_1363 P33 l=0.350u w=15.000u
M183 PAD VDD33 NET_61 NET_1363 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBD2

.subckt PBD16   PAD I OEN C FP
M1 VSS NET_107 NET_84 VSS N18 l=0.180u w=2.000u
M2 VSS NET_107 NET_84 VSS N18 l=0.180u w=2.000u
M3 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M5 C NET_84 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M7 C NET_84 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_51 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_51 VSS N18 l=0.180u w=2.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_51 VSS N18 l=0.180u w=2.000u
M13 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M14 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M15 NET_75 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_75 NET_76 NET_74 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_51 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_51 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_84 VDD P18 l=0.180u w=5.000u
M23 VDD NET_107 NET_84 VDD P18 l=0.180u w=5.000u
M24 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M25 C NET_84 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M27 C NET_84 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M32 NET_6045 OEN NET_51 VDD P18 l=0.180u w=5.000u
M33 NET_6045 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M35 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M36 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M37 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M38 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_76 NET_74 VDD P18 l=0.180u w=5.000u
M41 NET_74 NET_76 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M43 NET_92 NET_10 VSS VSS N33 l=0.350u w=8.000u
M44 VSS NET_45 NET_93 VSS N33 l=0.350u w=8.000u
M45 VSS NET_45 NET_93 VSS N33 l=0.350u w=8.000u
M46 NET_50 OEN VSS VSS N33 l=0.350u w=7.440u
M47 NET_50 OEN VSS VSS N33 l=0.350u w=7.440u
M48 VSS NET_76 NET_48 VSS N33 l=0.350u w=7.440u
M49 NET_48 NET_76 VSS VSS N33 l=0.350u w=7.440u
M50 VSS NET_59 NET_56 VSS N33 l=0.350u w=10.000u
M51 VSS NET_59 NET_56 VSS N33 l=0.350u w=10.000u
M52 VSS NET_74 NET_59 VSS N33 l=0.350u w=5.330u
M53 VSS NET_74 NET_59 VSS N33 l=0.350u w=5.330u
M54 NET_59 NET_74 VSS VSS N33 l=0.350u w=5.330u
M55 VSS NET_70 NET_60 VSS N33 l=0.350u w=5.330u
M56 NET_60 NET_70 VSS VSS N33 l=0.350u w=5.330u
M57 VSS NET_70 NET_60 VSS N33 l=0.350u w=5.330u
M58 NET_68 NET_3504 NET_66 VSS N33 l=0.350u w=8.000u
M59 NET_68 NET_50 VSS VSS N33 l=0.350u w=8.000u
M60 NET_92 NET_10 VSS VSS N33 l=0.350u w=8.000u
M61 VSS NET_51 NET_45 VSS N33 l=0.350u w=8.000u
M62 VSS NET_51 NET_45 VSS N33 l=0.350u w=8.000u
M63 NET_44 VDD33 NET_87 VSS N33 l=0.350u w=8.000u
M64 NET_44 VDD33 NET_87 VSS N33 l=0.350u w=8.000u
M65 NET_87 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M66 VSS NET_87 NET_96 VSS N33 l=0.350u w=8.000u
M67 NET_87 VDD33 VSS VSS N33 l=4.550u w=0.800u
M68 VSS NET_96 NET_107 VSS N33 l=0.350u w=2.000u
M69 VSS NET_96 NET_107 VSS N33 l=0.350u w=2.000u
M70 NET_41 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M73 NET_31 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M74 VSSD NET_93 NET_29 VSSD N33 l=0.400u w=28.000u
M75 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M76 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M77 NET_27 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M78 NET_43 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M80 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M81 NET_38 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M82 VSSD NET_93 NET_36 VSSD N33 l=0.400u w=28.000u
M83 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M84 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M85 NET_34 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M86 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M87 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M88 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M89 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M90 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M91 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M92 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M93 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M94 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M95 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M96 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M97 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M98 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M99 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M100 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M101 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M102 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M103 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M104 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M105 NET_107 NET_96 VDD VDD P33 l=0.300u w=5.000u
M106 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M107 NET_6014 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M108 NET_6014 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M109 NET_6016 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M110 NET_6016 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M111 NET_1363 NET_1363 NET_1363 NET_1363 P33 l=1.070u w=5.000u
M112 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M113 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M114 NET_107 NET_96 VDD VDD P33 l=0.300u w=5.000u
M115 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M116 PAD NET_66 NET_6007 NET_1363 P33 l=0.300u w=30.000u
M117 VDD33 NET_3504 NET_6007 NET_1363 P33 l=0.300u w=30.000u
M118 VDD33 NET_3504 NET_6005 NET_1363 P33 l=0.300u w=30.000u
M119 NET_6005 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M120 PAD NET_66 NET_6012 NET_1363 P33 l=0.300u w=30.000u
M121 VDD33 NET_3504 NET_6012 NET_1363 P33 l=0.300u w=30.000u
M122 VDD33 NET_3504 NET_6010 NET_1363 P33 l=0.300u w=30.000u
M123 NET_6010 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M124 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M125 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M126 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M127 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M128 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M130 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M131 PAD NET_66 NET_6003 NET_1363 P33 l=0.300u w=30.000u
M132 PAD NET_66 NET_6008 NET_1363 P33 l=0.300u w=30.000u
M133 NET_5997 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M134 NET_5997 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M135 PAD NET_66 NET_5995 NET_1363 P33 l=0.300u w=30.000u
M136 NET_6002 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M137 NET_6002 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M138 PAD NET_66 NET_6000 NET_1363 P33 l=0.300u w=30.000u
M139 NET_93 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M140 NET_93 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 NET_6003 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M142 NET_6008 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M143 VDD33 NET_56 NET_5993 NET_1363 P33 l=0.300u w=30.000u
M144 NET_5993 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M145 VDD33 NET_56 NET_5998 NET_1363 P33 l=0.300u w=30.000u
M146 NET_5998 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M147 VDD33 NET_45 NET_93 VDD33 P33 l=0.300u w=5.000u
M148 NET_93 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M149 NET_5983 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M150 NET_5983 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M151 NET_5988 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M152 NET_5988 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M153 VDD33 VSS NET_3504 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_45 NET_92 VDD33 P33 l=0.300u w=5.000u
M155 NET_45 NET_92 VDD33 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_56 NET_5981 NET_1363 P33 l=0.300u w=30.000u
M157 NET_5981 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M158 PAD NET_66 NET_5979 NET_1363 P33 l=0.300u w=30.000u
M159 VDD33 NET_56 NET_5986 NET_1363 P33 l=0.300u w=30.000u
M160 NET_5986 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M161 PAD NET_66 NET_5984 NET_1363 P33 l=0.300u w=30.000u
M162 VDD33 NET_50 NET_48 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_48 NET_50 VDD33 P33 l=0.300u w=5.000u
M164 NET_5970 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M165 NET_5974 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M166 NET_5979 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M167 NET_5984 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M168 PAD NET_66 NET_5968 NET_1363 P33 l=0.300u w=30.000u
M169 NET_5968 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M170 PAD NET_66 NET_5972 NET_1363 P33 l=0.300u w=30.000u
M171 NET_5972 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M172 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M173 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M174 VDD33 PAD NET_1363 NET_1363 P33 l=0.350u w=5.000u
M175 NET_56 NET_59 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 NET_56 NET_59 VDD33 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_59 NET_56 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_59 NET_60 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M181 NET_5995 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M182 NET_6000 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M183 NET_5970 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M184 NET_5974 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M185 PAD VDD33 NET_66 NET_1363 P33 l=0.350u w=10.000u
M186 PAD VDD33 NET_1363 NET_1363 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBD16

.subckt PBD12   PAD I OEN C FP
M1 VSS NET_107 NET_84 VSS N18 l=0.180u w=2.000u
M2 VSS NET_107 NET_84 VSS N18 l=0.180u w=2.000u
M3 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M4 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M5 C NET_84 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M7 C NET_84 VSS VSS N18 l=0.180u w=2.000u
M8 VSS NET_84 C VSS N18 l=0.180u w=2.000u
M9 VSS OEN NET_51 VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_51 VSS N18 l=0.180u w=2.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=2.000u
M12 VSS I NET_51 VSS N18 l=0.180u w=2.000u
M13 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M14 VSS NET_74 NET_70 VSS N18 l=0.180u w=4.000u
M15 NET_75 I VSS VSS N18 l=0.180u w=4.000u
M16 NET_75 NET_76 NET_74 VSS N18 l=0.180u w=4.000u
M17 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M18 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M19 VSS NET_51 NET_10 VSS N18 l=0.180u w=2.000u
M20 VSS NET_51 NET_10 VSS N18 l=0.180u w=2.000u
M21 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_107 NET_84 VDD P18 l=0.180u w=5.000u
M23 VDD NET_107 NET_84 VDD P18 l=0.180u w=5.000u
M24 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M25 C NET_84 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M27 C NET_84 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_84 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_76 VDD P18 l=0.180u w=5.000u
M32 NET_6045 OEN NET_51 VDD P18 l=0.180u w=5.000u
M33 NET_6045 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M35 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M36 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M37 VDD NET_74 NET_70 VDD P18 l=0.180u w=5.000u
M38 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_74 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_76 NET_74 VDD P18 l=0.180u w=5.000u
M41 NET_74 NET_76 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_51 NET_10 VDD P18 l=0.180u w=5.000u
M43 NET_92 NET_10 VSS VSS N33 l=0.350u w=8.000u
M44 VSS NET_45 NET_93 VSS N33 l=0.350u w=8.000u
M45 VSS NET_45 NET_93 VSS N33 l=0.350u w=8.000u
M46 NET_50 OEN VSS VSS N33 l=0.350u w=7.440u
M47 NET_50 OEN VSS VSS N33 l=0.350u w=7.440u
M48 VSS NET_76 NET_48 VSS N33 l=0.350u w=7.440u
M49 NET_48 NET_76 VSS VSS N33 l=0.350u w=7.440u
M50 VSS NET_59 NET_56 VSS N33 l=0.350u w=10.000u
M51 VSS NET_59 NET_56 VSS N33 l=0.350u w=10.000u
M52 VSS NET_74 NET_59 VSS N33 l=0.350u w=5.330u
M53 VSS NET_74 NET_59 VSS N33 l=0.350u w=5.330u
M54 NET_59 NET_74 VSS VSS N33 l=0.350u w=5.330u
M55 VSS NET_70 NET_60 VSS N33 l=0.350u w=5.330u
M56 NET_60 NET_70 VSS VSS N33 l=0.350u w=5.330u
M57 VSS NET_70 NET_60 VSS N33 l=0.350u w=5.330u
M58 NET_68 NET_3504 NET_66 VSS N33 l=0.350u w=8.000u
M59 NET_68 NET_50 VSS VSS N33 l=0.350u w=8.000u
M60 NET_92 NET_10 VSS VSS N33 l=0.350u w=8.000u
M61 VSS NET_51 NET_45 VSS N33 l=0.350u w=8.000u
M62 VSS NET_51 NET_45 VSS N33 l=0.350u w=8.000u
M63 NET_44 VDD33 NET_87 VSS N33 l=0.350u w=8.000u
M64 NET_44 VDD33 NET_87 VSS N33 l=0.350u w=8.000u
M65 NET_87 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M66 VSS NET_87 NET_96 VSS N33 l=0.350u w=8.000u
M67 NET_87 VDD33 VSS VSS N33 l=4.550u w=0.800u
M68 VSS NET_96 NET_107 VSS N33 l=0.350u w=2.000u
M69 VSS NET_96 NET_107 VSS N33 l=0.350u w=2.000u
M70 NET_41 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M73 NET_31 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M74 VSSD NET_93 NET_29 VSSD N33 l=0.400u w=28.000u
M75 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M76 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M77 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M78 NET_43 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M80 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M81 NET_38 NET_93 VSSD VSSD N33 l=0.400u w=28.000u
M82 VSSD NET_93 NET_36 VSSD N33 l=0.400u w=28.000u
M83 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M84 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M85 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M86 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M87 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M88 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M89 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M90 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M91 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M92 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M93 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M94 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M95 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M96 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M97 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M98 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M99 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M100 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M101 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M102 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M103 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M104 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M105 NET_107 NET_96 VDD VDD P33 l=0.300u w=5.000u
M106 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M107 NET_6014 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M108 NET_6014 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M109 NET_6016 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M110 NET_6016 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M111 NET_1363 NET_1363 NET_1363 NET_1363 P33 l=1.070u w=5.000u
M112 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M113 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M114 NET_107 NET_96 VDD VDD P33 l=0.300u w=5.000u
M115 VDD NET_96 NET_107 VDD P33 l=0.300u w=5.000u
M116 PAD NET_66 NET_6007 NET_1363 P33 l=0.300u w=30.000u
M117 VDD33 NET_3504 NET_6007 NET_1363 P33 l=0.300u w=30.000u
M118 VDD33 NET_3504 NET_6005 NET_1363 P33 l=0.300u w=30.000u
M119 NET_6005 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M120 PAD NET_66 NET_6012 NET_1363 P33 l=0.300u w=30.000u
M121 VDD33 NET_3504 NET_6012 NET_1363 P33 l=0.300u w=30.000u
M122 VDD33 NET_3504 NET_6010 NET_1363 P33 l=0.300u w=30.000u
M123 NET_6010 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M124 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M125 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M126 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M127 NET_96 NET_87 NET_3540 VDD33 P33 l=0.300u w=5.000u
M128 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M129 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M130 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M131 PAD NET_66 NET_6003 NET_1363 P33 l=0.300u w=30.000u
M132 PAD NET_66 NET_6008 NET_1363 P33 l=0.300u w=30.000u
M133 NET_5997 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M134 NET_5997 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M135 PAD NET_66 NET_5995 NET_1363 P33 l=0.300u w=30.000u
M136 NET_6002 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M137 NET_6002 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M138 PAD NET_66 NET_6000 NET_1363 P33 l=0.300u w=30.000u
M139 NET_93 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M140 NET_93 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 NET_6003 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M142 NET_6008 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M143 VDD33 NET_56 NET_5993 NET_1363 P33 l=0.300u w=30.000u
M144 NET_5993 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M145 VDD33 NET_56 NET_5998 NET_1363 P33 l=0.300u w=30.000u
M146 NET_5998 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M147 VDD33 NET_45 NET_93 VDD33 P33 l=0.300u w=5.000u
M148 NET_93 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M149 NET_5983 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M150 NET_5983 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M151 NET_5988 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M152 NET_5988 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M153 VDD33 VSS NET_3504 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_45 NET_92 VDD33 P33 l=0.300u w=5.000u
M155 NET_45 NET_92 VDD33 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_56 NET_5981 NET_1363 P33 l=0.300u w=30.000u
M157 NET_5981 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M158 PAD NET_66 NET_5979 NET_1363 P33 l=0.300u w=30.000u
M159 VDD33 NET_56 NET_5986 NET_1363 P33 l=0.300u w=30.000u
M160 NET_5986 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M161 PAD NET_66 NET_5984 NET_1363 P33 l=0.300u w=30.000u
M162 VDD33 NET_50 NET_48 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_48 NET_50 VDD33 P33 l=0.300u w=5.000u
M164 NET_5970 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M165 NET_5974 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M166 NET_5979 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M167 NET_5984 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M168 PAD NET_66 NET_5968 NET_1363 P33 l=0.300u w=30.000u
M169 NET_5968 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M170 PAD NET_66 NET_5972 NET_1363 P33 l=0.300u w=30.000u
M171 NET_5972 NET_56 VDD33 NET_1363 P33 l=0.300u w=30.000u
M172 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M173 NET_1363 PAD VDD33 NET_1363 P33 l=0.350u w=5.000u
M174 VDD33 PAD NET_1363 NET_1363 P33 l=0.350u w=5.000u
M175 NET_56 NET_59 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 NET_56 NET_59 VDD33 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_59 NET_56 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_59 NET_60 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_60 NET_59 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M181 NET_5995 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M182 NET_6000 NET_3504 VDD33 NET_1363 P33 l=0.300u w=30.000u
M183 NET_5970 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M184 NET_5974 NET_66 PAD NET_1363 P33 l=0.300u w=30.000u
M185 PAD VDD33 NET_66 NET_1363 P33 l=0.350u w=10.000u
M186 PAD VDD33 NET_1363 NET_1363 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBD12

.subckt PBL8   PAD OEN I C FP
M1 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M3 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M5 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M8 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M21 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M24 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M25 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M26 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M27 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M28 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M29 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 NET_5995 OEN NET_74 VDD P18 l=0.180u w=5.000u
M33 NET_5995 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M36 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M37 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M39 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M41 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M42 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M43 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M47 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M48 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M49 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_38 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M54 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M56 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M57 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M60 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M61 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M62 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M63 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M68 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M70 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_41 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M74 NET_43 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M78 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M79 NET_48 NET_49 VSS VSS N33 l=0.350u w=4.600u
M80 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M81 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M82 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M84 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M86 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M89 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M90 NET_63 NET_3497 NET_61 VSS N33 l=0.350u w=8.000u
M91 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M92 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M93 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M94 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M95 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M97 NET_88 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M98 VSS NET_88 NET_92 VSS N33 l=0.350u w=8.000u
M99 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M100 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M101 NET_5963 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M102 NET_5963 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M103 NET_5965 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M104 NET_5965 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M105 NET_1360 NET_1360 NET_1360 NET_1360 P33 l=1.070u w=5.000u
M106 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M107 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M108 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M109 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M110 NET_92 NET_88 NET_3540 VDD33 P33 l=0.300u w=5.000u
M111 NET_92 NET_88 NET_3540 VDD33 P33 l=0.300u w=5.000u
M112 NET_92 NET_88 NET_3540 VDD33 P33 l=0.300u w=5.000u
M113 NET_92 NET_88 NET_3540 VDD33 P33 l=0.300u w=5.000u
M114 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M115 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M116 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M117 PAD NET_61 NET_5956 NET_1360 P33 l=0.300u w=30.000u
M118 VDD33 NET_3497 NET_5956 NET_1360 P33 l=0.300u w=30.000u
M119 VDD33 NET_3497 NET_5954 NET_1360 P33 l=0.300u w=30.000u
M120 NET_5954 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M121 PAD NET_61 NET_5961 NET_1360 P33 l=0.300u w=30.000u
M122 VDD33 NET_3497 NET_5961 NET_1360 P33 l=0.300u w=30.000u
M123 VDD33 NET_3497 NET_5959 NET_1360 P33 l=0.300u w=30.000u
M124 NET_5959 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M125 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M126 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M127 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M129 PAD NET_61 NET_5952 NET_1360 P33 l=0.300u w=30.000u
M130 PAD NET_61 NET_5957 NET_1360 P33 l=0.300u w=30.000u
M131 NET_85 NET_46 VDD33 VDD33 P33 l=0.300u w=5.000u
M132 NET_5946 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M133 NET_5946 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M134 PAD NET_61 NET_5944 NET_1360 P33 l=0.300u w=30.000u
M135 NET_5951 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M136 NET_5951 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M137 PAD NET_61 NET_5949 NET_1360 P33 l=0.300u w=30.000u
M138 NET_5952 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M139 NET_5957 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M140 VDD33 NET_3497 NET_5942 NET_1360 P33 l=0.300u w=30.000u
M141 NET_5942 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M142 VDD33 NET_3497 NET_5947 NET_1360 P33 l=0.300u w=30.000u
M143 NET_5947 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M144 VDD33 VSS NET_3497 VDD33 P33 l=0.300u w=5.000u
M145 VDD33 NET_46 NET_84 VDD33 P33 l=0.300u w=5.000u
M146 NET_5932 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M147 NET_5932 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M148 NET_5937 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M149 NET_5937 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M150 NET_46 NET_84 VDD33 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_48 NET_5930 NET_1360 P33 l=0.300u w=30.000u
M154 NET_5930 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M155 PAD NET_61 NET_5928 NET_1360 P33 l=0.300u w=30.000u
M156 VDD33 NET_48 NET_5935 NET_1360 P33 l=0.300u w=30.000u
M157 NET_5935 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M158 PAD NET_61 NET_5933 NET_1360 P33 l=0.300u w=30.000u
M159 NET_5919 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M160 NET_5923 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M161 NET_5928 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M162 NET_5933 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M163 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M165 NET_48 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M169 PAD NET_61 NET_5917 NET_1360 P33 l=0.300u w=30.000u
M170 NET_5917 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M171 PAD NET_61 NET_5921 NET_1360 P33 l=0.300u w=30.000u
M172 NET_5921 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M173 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M174 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M175 VDD33 PAD NET_1360 NET_1360 P33 l=0.350u w=5.000u
M176 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M177 NET_5944 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M178 NET_5949 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M179 NET_5919 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M180 NET_5923 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_61 NET_1360 P33 l=0.350u w=10.000u
M182 PAD VDD33 NET_1360 NET_1360 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBL8

.subckt PBL24   PAD OEN I C FP
M1 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M3 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M5 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M8 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M21 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M24 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M25 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M26 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M27 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M28 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M29 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 NET_5993 OEN NET_74 VDD P18 l=0.180u w=5.000u
M33 NET_5993 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M36 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M37 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M39 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M41 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M42 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M43 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_85 NET_29 VSSD N33 l=0.400u w=28.000u
M47 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M48 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M49 NET_27 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_38 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_85 NET_36 VSSD N33 l=0.400u w=28.000u
M54 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M56 NET_34 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M57 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_16 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M60 VSSD NET_85 NET_14 VSSD N33 l=0.400u w=28.000u
M61 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M62 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M63 NET_12 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M64 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M68 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M70 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_41 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_85 NET_25 VSSD N33 l=0.400u w=28.000u
M74 NET_43 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M78 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M79 NET_48 NET_49 VSS VSS N33 l=0.350u w=4.400u
M80 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M81 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M82 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M84 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M86 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M89 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M90 NET_63 NET_3497 NET_61 VSS N33 l=0.350u w=8.000u
M91 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M92 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M93 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M94 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M95 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M97 NET_88 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M98 VSS NET_88 NET_92 VSS N33 l=0.350u w=8.000u
M99 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M100 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M101 NET_5961 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M102 NET_5961 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M103 NET_5963 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M104 NET_5963 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M105 NET_1360 NET_1360 NET_1360 NET_1360 P33 l=1.070u w=5.000u
M106 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M107 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M108 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M109 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M110 PAD NET_61 NET_5954 NET_1360 P33 l=0.300u w=30.000u
M111 VDD33 NET_48 NET_5954 NET_1360 P33 l=0.300u w=30.000u
M112 VDD33 NET_48 NET_5952 NET_1360 P33 l=0.300u w=30.000u
M113 NET_5952 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M114 PAD NET_61 NET_5959 NET_1360 P33 l=0.300u w=30.000u
M115 VDD33 NET_48 NET_5959 NET_1360 P33 l=0.300u w=30.000u
M116 VDD33 NET_48 NET_5957 NET_1360 P33 l=0.300u w=30.000u
M117 NET_5957 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M118 NET_92 NET_88 NET_3538 VDD33 P33 l=0.300u w=5.000u
M119 NET_92 NET_88 NET_3538 VDD33 P33 l=0.300u w=5.000u
M120 NET_92 NET_88 NET_3538 VDD33 P33 l=0.300u w=5.000u
M121 NET_92 NET_88 NET_3538 VDD33 P33 l=0.300u w=5.000u
M122 NET_3538 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_44 NET_3538 VDD33 P33 l=0.300u w=5.000u
M124 NET_3538 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M126 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M127 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M129 PAD NET_61 NET_5950 NET_1360 P33 l=0.300u w=30.000u
M130 PAD NET_61 NET_5955 NET_1360 P33 l=0.300u w=30.000u
M131 NET_5944 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M132 NET_5944 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M133 PAD NET_61 NET_5942 NET_1360 P33 l=0.300u w=30.000u
M134 NET_5949 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M135 NET_5949 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M136 PAD NET_61 NET_5947 NET_1360 P33 l=0.300u w=30.000u
M137 VDD33 NET_46 NET_85 VDD33 P33 l=0.300u w=4.600u
M138 NET_5950 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M139 NET_5955 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M140 VDD33 NET_48 NET_5940 NET_1360 P33 l=0.300u w=30.000u
M141 NET_5940 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M142 VDD33 NET_48 NET_5945 NET_1360 P33 l=0.300u w=30.000u
M143 NET_5945 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M144 NET_5930 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M145 NET_5930 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M146 NET_5935 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M147 NET_5935 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3497 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_46 NET_84 VDD33 P33 l=0.300u w=5.000u
M150 NET_46 NET_84 VDD33 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_48 NET_5928 NET_1360 P33 l=0.300u w=30.000u
M152 NET_5928 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M153 PAD NET_61 NET_5926 NET_1360 P33 l=0.300u w=30.000u
M154 VDD33 NET_48 NET_5933 NET_1360 P33 l=0.300u w=30.000u
M155 NET_5933 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M156 PAD NET_61 NET_5931 NET_1360 P33 l=0.300u w=30.000u
M157 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M158 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M159 NET_5917 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M160 NET_5921 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M161 NET_5926 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M162 NET_5931 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M163 PAD NET_61 NET_5915 NET_1360 P33 l=0.300u w=30.000u
M164 NET_5915 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M165 PAD NET_61 NET_5919 NET_1360 P33 l=0.300u w=30.000u
M166 NET_5919 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M167 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M168 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M169 VDD33 PAD NET_1360 NET_1360 P33 l=0.350u w=5.000u
M170 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M172 NET_48 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_44 NET_3538 VDD33 P33 l=0.300u w=5.000u
M177 NET_5942 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M178 NET_5947 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M179 NET_5917 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M180 NET_5921 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_61 NET_1360 P33 l=0.350u w=10.000u
M182 PAD VDD33 NET_1360 NET_1360 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBL24

.subckt PBL16   PAD OEN I C FP
M1 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M3 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M5 C NET_101 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_101 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M8 VSS NET_104 NET_101 VSS N18 l=0.180u w=2.000u
M9 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M19 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_45 VSS N18 l=0.180u w=2.000u
M21 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M23 VDD NET_104 NET_101 VDD P18 l=0.180u w=5.000u
M24 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M25 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M26 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M27 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M28 C NET_101 VDD VDD P18 l=0.180u w=5.000u
M29 VDD NET_101 C VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M32 NET_5985 OEN NET_74 VDD P18 l=0.180u w=5.000u
M33 NET_5985 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M35 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M36 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M37 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M39 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M41 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M42 VDD NET_74 NET_45 VDD P18 l=0.180u w=5.000u
M43 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M44 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M46 VSSD NET_85 NET_29 VSSD N33 l=0.400u w=28.000u
M47 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M48 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M49 NET_27 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M50 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M51 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M52 NET_38 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M53 VSSD NET_85 NET_36 VSSD N33 l=0.400u w=28.000u
M54 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M55 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M56 NET_34 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M57 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M59 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M60 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M61 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M62 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M63 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M68 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M70 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M72 NET_41 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M74 NET_43 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M78 VSS NET_46 NET_85 VSS N33 l=0.350u w=8.000u
M79 NET_48 NET_49 VSS VSS N33 l=0.350u w=3.400u
M80 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M81 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M82 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M83 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M84 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M86 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M87 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M88 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M89 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M90 NET_63 NET_3497 NET_61 VSS N33 l=0.350u w=8.000u
M91 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M92 NET_84 NET_45 VSS VSS N33 l=0.350u w=8.000u
M93 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M94 NET_46 NET_74 VSS VSS N33 l=0.350u w=8.000u
M95 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_88 VSS N33 l=0.350u w=8.000u
M97 NET_88 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M98 VSS NET_88 NET_92 VSS N33 l=0.350u w=8.000u
M99 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M100 VSS NET_92 NET_104 VSS N33 l=0.350u w=2.000u
M101 NET_5953 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M102 NET_5953 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M103 NET_5955 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M104 NET_5955 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M105 NET_1360 NET_1360 NET_1360 NET_1360 P33 l=1.070u w=5.000u
M106 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M107 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M108 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M109 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M110 NET_92 NET_88 NET_3538 VDD33 P33 l=0.300u w=5.000u
M111 NET_92 NET_88 NET_3538 VDD33 P33 l=0.300u w=5.000u
M112 NET_92 NET_88 NET_3538 VDD33 P33 l=0.300u w=5.000u
M113 NET_92 NET_88 NET_3538 VDD33 P33 l=0.300u w=5.000u
M114 NET_3538 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M115 VDD33 NET_44 NET_3538 VDD33 P33 l=0.300u w=5.000u
M116 NET_3538 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M117 PAD NET_61 NET_5946 NET_1360 P33 l=0.300u w=30.000u
M118 VDD33 NET_3497 NET_5946 NET_1360 P33 l=0.300u w=30.000u
M119 VDD33 NET_3497 NET_5944 NET_1360 P33 l=0.300u w=30.000u
M120 NET_5944 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M121 PAD NET_61 NET_5951 NET_1360 P33 l=0.300u w=30.000u
M122 VDD33 NET_3497 NET_5951 NET_1360 P33 l=0.300u w=30.000u
M123 VDD33 NET_3497 NET_5949 NET_1360 P33 l=0.300u w=30.000u
M124 NET_5949 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M125 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M126 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M127 NET_104 NET_92 VDD VDD P33 l=0.300u w=5.000u
M128 VDD NET_92 NET_104 VDD P33 l=0.300u w=5.000u
M129 PAD NET_61 NET_5942 NET_1360 P33 l=0.300u w=30.000u
M130 PAD NET_61 NET_5947 NET_1360 P33 l=0.300u w=30.000u
M131 NET_85 NET_46 VDD33 VDD33 P33 l=0.300u w=3.600u
M132 NET_5936 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M133 NET_5936 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M134 PAD NET_61 NET_5934 NET_1360 P33 l=0.300u w=30.000u
M135 NET_5941 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M136 NET_5941 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M137 PAD NET_61 NET_5939 NET_1360 P33 l=0.300u w=30.000u
M138 NET_5942 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M139 NET_5947 NET_3497 VDD33 NET_1360 P33 l=0.300u w=30.000u
M140 VDD33 NET_48 NET_5932 NET_1360 P33 l=0.300u w=30.000u
M141 NET_5932 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M142 VDD33 NET_48 NET_5937 NET_1360 P33 l=0.300u w=30.000u
M143 NET_5937 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M144 VDD33 VSS NET_3497 VDD33 P33 l=0.300u w=5.000u
M145 VDD33 NET_46 NET_84 VDD33 P33 l=0.300u w=5.000u
M146 NET_5922 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M147 NET_5922 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M148 NET_5927 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M149 NET_5927 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M150 NET_46 NET_84 VDD33 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_48 NET_5920 NET_1360 P33 l=0.300u w=30.000u
M154 NET_5920 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M155 PAD NET_61 NET_5918 NET_1360 P33 l=0.300u w=30.000u
M156 VDD33 NET_48 NET_5925 NET_1360 P33 l=0.300u w=30.000u
M157 NET_5925 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M158 PAD NET_61 NET_5923 NET_1360 P33 l=0.300u w=30.000u
M159 NET_5909 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M160 NET_5913 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M161 NET_5918 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M162 NET_5923 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M163 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M165 NET_48 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M169 PAD NET_61 NET_5907 NET_1360 P33 l=0.300u w=30.000u
M170 NET_5907 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M171 PAD NET_61 NET_5911 NET_1360 P33 l=0.300u w=30.000u
M172 NET_5911 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M173 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M174 NET_1360 PAD VDD33 NET_1360 P33 l=0.350u w=5.000u
M175 VDD33 PAD NET_1360 NET_1360 P33 l=0.350u w=5.000u
M176 VDD33 NET_44 NET_3538 VDD33 P33 l=0.300u w=5.000u
M177 NET_5934 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M178 NET_5939 NET_48 VDD33 NET_1360 P33 l=0.300u w=30.000u
M179 NET_5909 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M180 NET_5913 NET_61 PAD NET_1360 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_61 NET_1360 P33 l=0.350u w=10.000u
M182 PAD VDD33 NET_1360 NET_1360 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBL16

.subckt PBL12   PAD OEN I C FP
M1 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M3 C NET_102 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M5 C NET_102 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_105 NET_102 VSS N18 l=0.180u w=2.000u
M8 VSS NET_105 NET_102 VSS N18 l=0.180u w=2.000u
M9 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M10 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_71 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_71 NET_72 NET_70 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M17 NET_75 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_75 VSS N18 l=0.180u w=2.000u
M19 VSS NET_75 NET_45 VSS N18 l=0.180u w=2.000u
M20 VSS NET_75 NET_45 VSS N18 l=0.180u w=2.000u
M21 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_105 NET_102 VDD P18 l=0.180u w=5.000u
M23 VDD NET_105 NET_102 VDD P18 l=0.180u w=5.000u
M24 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M25 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M26 C NET_102 VDD VDD P18 l=0.180u w=5.000u
M27 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M28 C NET_102 VDD VDD P18 l=0.180u w=5.000u
M29 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M32 NET_6018 OEN NET_75 VDD P18 l=0.180u w=5.000u
M33 NET_6018 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M35 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M36 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M37 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_72 NET_70 VDD P18 l=0.180u w=5.000u
M39 NET_70 NET_72 VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M41 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M42 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_86 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_86 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M62 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M63 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M64 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M65 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M70 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M72 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M74 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_85 NET_45 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_46 NET_86 VSS N33 l=0.350u w=8.000u
M78 VSS NET_46 NET_86 VSS N33 l=0.350u w=8.000u
M79 VSS NET_50 NET_47 VSS N33 l=0.350u w=5.000u
M80 VSS NET_50 NET_47 VSS N33 l=0.350u w=5.000u
M81 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M82 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M83 NET_50 NET_70 VSS VSS N33 l=0.350u w=5.330u
M84 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M85 NET_51 NET_66 VSS VSS N33 l=0.350u w=5.330u
M86 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M87 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M88 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M89 VSS NET_72 NET_59 VSS N33 l=0.350u w=7.440u
M90 NET_59 NET_72 VSS VSS N33 l=0.350u w=7.440u
M91 NET_64 NET_3498 NET_62 VSS N33 l=0.350u w=8.000u
M92 NET_64 NET_61 VSS VSS N33 l=0.350u w=8.000u
M93 NET_85 NET_45 VSS VSS N33 l=0.350u w=8.000u
M94 NET_46 NET_75 VSS VSS N33 l=0.350u w=8.000u
M95 NET_46 NET_75 VSS VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_89 VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_89 VSS N33 l=0.350u w=8.000u
M98 NET_89 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M99 VSS NET_89 NET_93 VSS N33 l=0.350u w=8.000u
M100 VSS NET_93 NET_105 VSS N33 l=0.350u w=2.000u
M101 VSS NET_93 NET_105 VSS N33 l=0.350u w=2.000u
M102 NET_5986 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M103 NET_5986 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M104 NET_5988 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M105 NET_5988 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M106 NET_1361 NET_1361 NET_1361 NET_1361 P33 l=1.070u w=5.000u
M107 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M108 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M109 NET_105 NET_93 VDD VDD P33 l=0.300u w=5.000u
M110 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M111 NET_93 NET_89 NET_3542 VDD33 P33 l=0.300u w=5.000u
M112 NET_93 NET_89 NET_3542 VDD33 P33 l=0.300u w=5.000u
M113 NET_93 NET_89 NET_3542 VDD33 P33 l=0.300u w=5.000u
M114 NET_93 NET_89 NET_3542 VDD33 P33 l=0.300u w=5.000u
M115 NET_3542 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_44 NET_3542 VDD33 P33 l=0.300u w=5.000u
M117 NET_3542 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M118 PAD NET_62 NET_5979 NET_1361 P33 l=0.300u w=30.000u
M119 VDD33 NET_3498 NET_5979 NET_1361 P33 l=0.300u w=30.000u
M120 VDD33 NET_3498 NET_5977 NET_1361 P33 l=0.300u w=30.000u
M121 NET_5977 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M122 PAD NET_62 NET_5984 NET_1361 P33 l=0.300u w=30.000u
M123 VDD33 NET_3498 NET_5984 NET_1361 P33 l=0.300u w=30.000u
M124 VDD33 NET_3498 NET_5982 NET_1361 P33 l=0.300u w=30.000u
M125 NET_5982 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M126 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M127 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M128 NET_105 NET_93 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M130 PAD NET_62 NET_5975 NET_1361 P33 l=0.300u w=30.000u
M131 PAD NET_62 NET_5980 NET_1361 P33 l=0.300u w=30.000u
M132 VDD33 NET_46 NET_86 VDD33 P33 l=0.300u w=4.800u
M133 VDD33 NET_46 NET_86 VDD33 P33 l=0.300u w=4.800u
M134 NET_5969 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M135 NET_5969 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M136 PAD NET_62 NET_5967 NET_1361 P33 l=0.300u w=30.000u
M137 NET_5974 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M138 NET_5974 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M139 PAD NET_62 NET_5972 NET_1361 P33 l=0.300u w=30.000u
M140 NET_5975 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M141 NET_5980 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M142 VDD33 NET_47 NET_5965 NET_1361 P33 l=0.300u w=30.000u
M143 NET_5965 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M144 VDD33 NET_47 NET_5970 NET_1361 P33 l=0.300u w=30.000u
M145 NET_5970 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M146 VDD33 VSS NET_3498 VDD33 P33 l=0.300u w=5.000u
M147 VDD33 NET_46 NET_85 VDD33 P33 l=0.300u w=5.000u
M148 NET_5955 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M149 NET_5955 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M150 NET_5960 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M151 NET_5960 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M152 NET_46 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_61 NET_59 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_59 NET_61 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_47 NET_5953 NET_1361 P33 l=0.300u w=30.000u
M156 NET_5953 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M157 PAD NET_62 NET_5951 NET_1361 P33 l=0.300u w=30.000u
M158 VDD33 NET_47 NET_5958 NET_1361 P33 l=0.300u w=30.000u
M159 NET_5958 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M160 PAD NET_62 NET_5956 NET_1361 P33 l=0.300u w=30.000u
M161 NET_5942 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M162 NET_5946 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M163 NET_5951 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M164 NET_5956 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M165 VDD33 NET_50 NET_47 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_50 NET_47 VDD33 P33 l=0.300u w=5.000u
M167 NET_47 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_50 NET_47 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_50 NET_51 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M171 PAD NET_62 NET_5940 NET_1361 P33 l=0.300u w=30.000u
M172 NET_5940 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M173 PAD NET_62 NET_5944 NET_1361 P33 l=0.300u w=30.000u
M174 NET_5944 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M175 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M176 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M177 VDD33 PAD NET_1361 NET_1361 P33 l=0.350u w=5.000u
M178 VDD33 NET_44 NET_3542 VDD33 P33 l=0.300u w=5.000u
M179 NET_5967 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M180 NET_5972 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M181 NET_5942 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M182 NET_5946 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_62 NET_1361 P33 l=0.350u w=10.000u
M184 PAD VDD33 NET_1361 NET_1361 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PBL12

.subckt PBCUL8   PAD OEN I C REN FP
M1 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M2 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M4 C NET_107 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M6 C NET_107 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_110 NET_107 VSS N18 l=0.180u w=2.000u
M9 VSS NET_110 NET_107 VSS N18 l=0.180u w=2.000u
M10 VSS NET_67 NET_63 VSS N18 l=0.180u w=4.000u
M11 VSS NET_67 NET_63 VSS N18 l=0.180u w=4.000u
M12 NET_68 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_68 NET_69 NET_67 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_69 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_69 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M18 NET_72 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_72 VSS N18 l=0.180u w=2.000u
M20 NET_77 NET_72 VSS VSS N18 l=0.180u w=2.000u
M21 VSS NET_72 NET_77 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M23 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_110 NET_107 VDD P18 l=0.180u w=5.000u
M25 VDD NET_110 NET_107 VDD P18 l=0.180u w=5.000u
M26 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M27 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M29 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M30 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M31 C NET_107 VDD VDD P18 l=0.180u w=5.000u
M32 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M33 C NET_107 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_69 VDD P18 l=0.180u w=5.000u
M36 VDD OEN NET_69 VDD P18 l=0.180u w=5.000u
M37 NET_5971 OEN NET_72 VDD P18 l=0.180u w=5.000u
M38 NET_5971 I VDD VDD P18 l=0.180u w=5.000u
M39 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M40 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M41 VDD NET_67 NET_63 VDD P18 l=0.180u w=5.000u
M42 VDD NET_67 NET_63 VDD P18 l=0.180u w=5.000u
M43 NET_67 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_67 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_69 NET_67 VDD P18 l=0.180u w=5.000u
M46 NET_67 NET_69 VDD VDD P18 l=0.180u w=5.000u
M47 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_32 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_24 NET_30 VSSD N33 l=0.400u w=28.000u
M51 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M52 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M53 NET_28 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M55 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M56 NET_39 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_24 NET_37 VSSD N33 l=0.400u w=28.000u
M58 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M60 NET_35 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M65 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M67 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_42 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_24 NET_26 VSSD N33 l=0.400u w=28.000u
M78 NET_44 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_33 VSSD N33 l=0.400u w=28.000u
M80 NET_85 NET_77 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_10 NET_86 VSS N33 l=0.350u w=8.000u
M82 VSS NET_10 NET_86 VSS N33 l=0.350u w=8.000u
M83 NET_46 NET_47 VSS VSS N33 l=0.350u w=4.600u
M84 VSS NET_67 NET_47 VSS N33 l=0.350u w=5.330u
M85 VSS NET_67 NET_47 VSS N33 l=0.350u w=5.330u
M86 NET_47 NET_67 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_63 NET_48 VSS N33 l=0.350u w=5.330u
M88 NET_48 NET_63 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_63 NET_48 VSS N33 l=0.350u w=5.330u
M90 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M91 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M92 VSS NET_69 NET_56 VSS N33 l=0.350u w=7.440u
M93 NET_56 NET_69 VSS VSS N33 l=0.350u w=7.440u
M94 NET_61 NET_3499 NET_59 VSS N33 l=0.350u w=8.000u
M95 NET_61 NET_58 VSS VSS N33 l=0.350u w=8.000u
M96 NET_85 NET_77 VSS VSS N33 l=0.350u w=8.000u
M97 VSS NET_72 NET_10 VSS N33 l=0.350u w=8.000u
M98 VSS NET_72 NET_10 VSS N33 l=0.350u w=8.000u
M99 VSS REN NET_89 VSS N33 l=0.350u w=8.000u
M100 VSS NET_82 NET_90 VSS N33 l=0.350u w=8.000u
M101 NET_40 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M102 NET_40 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M103 NET_92 VDD33 NET_40 VSS N33 l=0.350u w=8.000u
M104 VSS NET_92 NET_96 VSS N33 l=0.350u w=8.000u
M105 VDD NET_89 NET_116 VSS N33 l=0.350u w=4.000u
M106 VSS NET_96 NET_110 VSS N33 l=0.350u w=2.000u
M107 VSS NET_96 NET_110 VSS N33 l=0.350u w=2.000u
M108 VDD33 NET_89 NET_116 VDD33 P33 l=0.300u w=5.000u
M109 NET_5940 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M110 NET_5940 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M111 NET_5944 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M112 NET_5944 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M113 VDD33 NET_116 NET_40 NET_1369 P33 l=1.070u w=5.000u
M114 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M115 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M116 NET_110 NET_96 VDD VDD P33 l=0.300u w=5.000u
M117 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M118 NET_96 NET_92 NET_3536 VDD33 P33 l=0.300u w=5.000u
M119 NET_96 NET_92 NET_3536 VDD33 P33 l=0.300u w=5.000u
M120 NET_3536 NET_92 NET_96 VDD33 P33 l=0.300u w=5.000u
M121 NET_96 NET_92 NET_3536 VDD33 P33 l=0.300u w=5.000u
M122 NET_3536 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_40 NET_3536 VDD33 P33 l=0.300u w=5.000u
M124 NET_3536 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 PAD NET_59 NET_5928 NET_1369 P33 l=0.300u w=30.000u
M126 VDD33 NET_3499 NET_5928 NET_1369 P33 l=0.300u w=30.000u
M127 VDD33 NET_3499 NET_5926 NET_1369 P33 l=0.300u w=30.000u
M128 NET_5926 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M129 PAD NET_59 NET_5938 NET_1369 P33 l=0.300u w=30.000u
M130 VDD33 NET_3499 NET_5938 NET_1369 P33 l=0.300u w=30.000u
M131 VDD33 NET_3499 NET_5937 NET_1369 P33 l=0.300u w=30.000u
M132 NET_5937 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M133 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M134 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M135 NET_110 NET_96 VDD VDD P33 l=0.300u w=5.000u
M136 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M137 PAD NET_59 NET_5924 NET_1369 P33 l=0.300u w=30.000u
M138 PAD NET_59 NET_5935 NET_1369 P33 l=0.300u w=30.000u
M139 VDD33 NET_89 NET_90 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_90 NET_89 VDD33 P33 l=0.300u w=5.000u
M141 NET_86 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 NET_5923 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M143 NET_5923 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M144 PAD NET_59 NET_5921 NET_1369 P33 l=0.300u w=30.000u
M145 NET_5934 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M146 NET_5934 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M147 PAD NET_59 NET_5917 NET_1369 P33 l=0.300u w=30.000u
M148 NET_5924 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M149 NET_5935 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M150 VDD33 NET_3499 NET_5919 NET_1369 P33 l=0.300u w=30.000u
M151 NET_5919 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M152 VDD33 NET_3499 NET_5929 NET_1369 P33 l=0.300u w=30.000u
M153 NET_5929 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M154 VDD33 VSS NET_3499 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_10 NET_85 VDD33 P33 l=0.300u w=5.000u
M156 NET_5900 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M157 NET_5900 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M158 NET_5914 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M159 NET_5914 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M160 NET_10 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_58 NET_56 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_56 NET_58 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_46 NET_5898 NET_1369 P33 l=0.300u w=30.000u
M164 NET_5898 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M165 PAD NET_59 NET_5896 NET_1369 P33 l=0.300u w=30.000u
M166 VDD33 NET_46 NET_5912 NET_1369 P33 l=0.300u w=30.000u
M167 NET_5912 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M168 PAD NET_59 NET_5911 NET_1369 P33 l=0.300u w=30.000u
M169 NET_5895 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M170 NET_5910 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M171 NET_5896 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M172 NET_5911 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M173 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M175 NET_46 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_47 NET_48 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M179 PAD NET_59 NET_5893 NET_1369 P33 l=0.300u w=30.000u
M180 NET_5893 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M181 PAD NET_59 NET_5908 NET_1369 P33 l=0.300u w=30.000u
M182 NET_5908 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M183 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M184 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M185 VDD33 PAD NET_1369 NET_1369 P33 l=0.350u w=5.000u
M186 VDD33 NET_40 NET_3536 VDD33 P33 l=0.300u w=5.000u
M187 NET_5921 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M188 NET_5917 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M189 NET_5895 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M190 NET_5910 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M191 PAD VDD33 NET_1369 NET_1369 P33 l=0.350u w=15.000u
M192 PAD VDD33 NET_59 NET_1369 P33 l=0.350u w=10.000u
R1 PAD NET_40 300.135
.ends PBCUL8

.subckt PBCUL24   PAD OEN I C REN FP
M1 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M2 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M4 C NET_107 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M6 C NET_107 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_110 NET_107 VSS N18 l=0.180u w=2.000u
M9 VSS NET_110 NET_107 VSS N18 l=0.180u w=2.000u
M10 VSS NET_67 NET_63 VSS N18 l=0.180u w=4.000u
M11 VSS NET_67 NET_63 VSS N18 l=0.180u w=4.000u
M12 NET_68 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_68 NET_69 NET_67 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_69 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_69 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M18 NET_72 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_72 VSS N18 l=0.180u w=2.000u
M20 NET_77 NET_72 VSS VSS N18 l=0.180u w=2.000u
M21 VSS NET_72 NET_77 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M23 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_110 NET_107 VDD P18 l=0.180u w=5.000u
M25 VDD NET_110 NET_107 VDD P18 l=0.180u w=5.000u
M26 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M27 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M29 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M30 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M31 C NET_107 VDD VDD P18 l=0.180u w=5.000u
M32 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M33 C NET_107 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_69 VDD P18 l=0.180u w=5.000u
M36 VDD OEN NET_69 VDD P18 l=0.180u w=5.000u
M37 NET_5969 OEN NET_72 VDD P18 l=0.180u w=5.000u
M38 NET_5969 I VDD VDD P18 l=0.180u w=5.000u
M39 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M40 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M41 VDD NET_67 NET_63 VDD P18 l=0.180u w=5.000u
M42 VDD NET_67 NET_63 VDD P18 l=0.180u w=5.000u
M43 NET_67 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_67 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_69 NET_67 VDD P18 l=0.180u w=5.000u
M46 NET_67 NET_69 VDD VDD P18 l=0.180u w=5.000u
M47 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_32 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_86 NET_30 VSSD N33 l=0.400u w=28.000u
M51 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M52 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M53 NET_28 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M55 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M56 NET_39 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_86 NET_37 VSSD N33 l=0.400u w=28.000u
M58 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M60 NET_35 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_17 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_24 NET_15 VSSD N33 l=0.400u w=28.000u
M65 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M67 NET_13 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_86 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_42 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_24 NET_26 VSSD N33 l=0.400u w=28.000u
M78 NET_44 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_86 NET_33 VSSD N33 l=0.400u w=28.000u
M80 NET_85 NET_77 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_10 NET_86 VSS N33 l=0.350u w=8.000u
M82 VSS NET_10 NET_86 VSS N33 l=0.350u w=8.000u
M83 NET_46 NET_47 VSS VSS N33 l=0.350u w=4.400u
M84 VSS NET_67 NET_47 VSS N33 l=0.350u w=5.330u
M85 VSS NET_67 NET_47 VSS N33 l=0.350u w=5.330u
M86 NET_47 NET_67 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_63 NET_48 VSS N33 l=0.350u w=5.330u
M88 NET_48 NET_63 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_63 NET_48 VSS N33 l=0.350u w=5.330u
M90 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M91 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M92 VSS NET_69 NET_56 VSS N33 l=0.350u w=7.440u
M93 NET_56 NET_69 VSS VSS N33 l=0.350u w=7.440u
M94 NET_61 NET_3499 NET_59 VSS N33 l=0.350u w=8.000u
M95 NET_61 NET_58 VSS VSS N33 l=0.350u w=8.000u
M96 NET_85 NET_77 VSS VSS N33 l=0.350u w=8.000u
M97 VSS NET_72 NET_10 VSS N33 l=0.350u w=8.000u
M98 VSS NET_72 NET_10 VSS N33 l=0.350u w=8.000u
M99 VSS REN NET_89 VSS N33 l=0.350u w=8.000u
M100 VSS NET_82 NET_90 VSS N33 l=0.350u w=8.000u
M101 NET_40 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M102 NET_40 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M103 NET_92 VDD33 NET_40 VSS N33 l=0.350u w=8.000u
M104 VSS NET_92 NET_96 VSS N33 l=0.350u w=8.000u
M105 VDD NET_89 NET_116 VSS N33 l=0.350u w=4.000u
M106 VSS NET_96 NET_110 VSS N33 l=0.350u w=2.000u
M107 VSS NET_96 NET_110 VSS N33 l=0.350u w=2.000u
M108 NET_5938 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M109 NET_5938 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M110 NET_5942 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M111 NET_5942 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M112 VDD33 NET_116 NET_40 NET_1369 P33 l=1.070u w=5.000u
M113 VDD33 NET_89 NET_116 VDD33 P33 l=0.300u w=5.000u
M114 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M115 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M116 NET_110 NET_96 VDD VDD P33 l=0.300u w=5.000u
M117 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M118 PAD NET_59 NET_5926 NET_1369 P33 l=0.300u w=30.000u
M119 VDD33 NET_46 NET_5926 NET_1369 P33 l=0.300u w=30.000u
M120 VDD33 NET_46 NET_5924 NET_1369 P33 l=0.300u w=30.000u
M121 NET_5924 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M122 PAD NET_59 NET_5936 NET_1369 P33 l=0.300u w=30.000u
M123 VDD33 NET_46 NET_5936 NET_1369 P33 l=0.300u w=30.000u
M124 VDD33 NET_46 NET_5935 NET_1369 P33 l=0.300u w=30.000u
M125 NET_5935 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M126 NET_96 NET_92 NET_3534 VDD33 P33 l=0.300u w=5.000u
M127 NET_96 NET_92 NET_3534 VDD33 P33 l=0.300u w=5.000u
M128 NET_3534 NET_92 NET_96 VDD33 P33 l=0.300u w=5.000u
M129 NET_96 NET_92 NET_3534 VDD33 P33 l=0.300u w=5.000u
M130 NET_3534 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M131 VDD33 NET_40 NET_3534 VDD33 P33 l=0.300u w=5.000u
M132 NET_3534 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M133 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M134 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M135 NET_110 NET_96 VDD VDD P33 l=0.300u w=5.000u
M136 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M137 PAD NET_59 NET_5922 NET_1369 P33 l=0.300u w=30.000u
M138 PAD NET_59 NET_5933 NET_1369 P33 l=0.300u w=30.000u
M139 NET_5921 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M140 NET_5921 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M141 PAD NET_59 NET_5919 NET_1369 P33 l=0.300u w=30.000u
M142 NET_5932 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M143 NET_5932 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M144 PAD NET_59 NET_5915 NET_1369 P33 l=0.300u w=30.000u
M145 VDD33 NET_89 NET_90 VDD33 P33 l=0.300u w=5.000u
M146 VDD33 NET_90 NET_89 VDD33 P33 l=0.300u w=5.000u
M147 VDD33 NET_10 NET_86 VDD33 P33 l=0.300u w=4.600u
M148 NET_5922 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M149 NET_5933 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M150 VDD33 NET_46 NET_5917 NET_1369 P33 l=0.300u w=30.000u
M151 NET_5917 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M152 VDD33 NET_46 NET_5927 NET_1369 P33 l=0.300u w=30.000u
M153 NET_5927 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M154 NET_5898 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M155 NET_5898 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M156 NET_5912 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M157 NET_5912 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M158 VDD33 VSS NET_3499 VDD33 P33 l=0.300u w=5.000u
M159 VDD33 NET_10 NET_85 VDD33 P33 l=0.300u w=5.000u
M160 NET_10 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_46 NET_5896 NET_1369 P33 l=0.300u w=30.000u
M162 NET_5896 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M163 PAD NET_59 NET_5894 NET_1369 P33 l=0.300u w=30.000u
M164 VDD33 NET_46 NET_5910 NET_1369 P33 l=0.300u w=30.000u
M165 NET_5910 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M166 PAD NET_59 NET_5909 NET_1369 P33 l=0.300u w=30.000u
M167 VDD33 NET_58 NET_56 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_56 NET_58 VDD33 P33 l=0.300u w=5.000u
M169 NET_5893 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M170 NET_5908 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M171 NET_5894 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M172 NET_5909 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M173 PAD NET_59 NET_5891 NET_1369 P33 l=0.300u w=30.000u
M174 NET_5891 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M175 PAD NET_59 NET_5906 NET_1369 P33 l=0.300u w=30.000u
M176 NET_5906 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M177 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M178 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M179 VDD33 PAD NET_1369 NET_1369 P33 l=0.350u w=5.000u
M180 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M181 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M182 NET_46 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M183 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M184 VDD33 NET_47 NET_48 VDD33 P33 l=0.300u w=5.000u
M185 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M186 VDD33 NET_40 NET_3534 VDD33 P33 l=0.300u w=5.000u
M187 NET_5919 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M188 NET_5915 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M189 NET_5893 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M190 NET_5908 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M191 PAD VDD33 NET_1369 NET_1369 P33 l=0.350u w=15.000u
M192 PAD VDD33 NET_59 NET_1369 P33 l=0.350u w=10.000u
R1 PAD NET_40 300.135
.ends PBCUL24

.subckt PBCUL16   PAD OEN I C REN FP
M1 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M2 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M4 C NET_107 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M6 C NET_107 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_107 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_110 NET_107 VSS N18 l=0.180u w=2.000u
M9 VSS NET_110 NET_107 VSS N18 l=0.180u w=2.000u
M10 VSS NET_67 NET_63 VSS N18 l=0.180u w=4.000u
M11 VSS NET_67 NET_63 VSS N18 l=0.180u w=4.000u
M12 NET_68 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_68 NET_69 NET_67 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_69 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_69 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M18 NET_72 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_72 VSS N18 l=0.180u w=2.000u
M20 NET_77 NET_72 VSS VSS N18 l=0.180u w=2.000u
M21 VSS NET_72 NET_77 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M23 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_110 NET_107 VDD P18 l=0.180u w=5.000u
M25 VDD NET_110 NET_107 VDD P18 l=0.180u w=5.000u
M26 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M27 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M29 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M30 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M31 C NET_107 VDD VDD P18 l=0.180u w=5.000u
M32 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M33 C NET_107 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_107 C VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_69 VDD P18 l=0.180u w=5.000u
M36 VDD OEN NET_69 VDD P18 l=0.180u w=5.000u
M37 NET_5961 OEN NET_72 VDD P18 l=0.180u w=5.000u
M38 NET_5961 I VDD VDD P18 l=0.180u w=5.000u
M39 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M40 VDD NET_72 NET_77 VDD P18 l=0.180u w=5.000u
M41 VDD NET_67 NET_63 VDD P18 l=0.180u w=5.000u
M42 VDD NET_67 NET_63 VDD P18 l=0.180u w=5.000u
M43 NET_67 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_67 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_69 NET_67 VDD P18 l=0.180u w=5.000u
M46 NET_67 NET_69 VDD VDD P18 l=0.180u w=5.000u
M47 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_32 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_86 NET_30 VSSD N33 l=0.400u w=28.000u
M51 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M52 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M53 NET_28 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M55 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M56 NET_39 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_86 NET_37 VSSD N33 l=0.400u w=28.000u
M58 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M60 NET_35 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_17 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_24 NET_15 VSSD N33 l=0.400u w=28.000u
M65 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M67 NET_13 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_42 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_24 NET_26 VSSD N33 l=0.400u w=28.000u
M78 NET_44 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_33 VSSD N33 l=0.400u w=28.000u
M80 NET_85 NET_77 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_10 NET_86 VSS N33 l=0.350u w=8.000u
M82 VSS NET_10 NET_86 VSS N33 l=0.350u w=8.000u
M83 NET_46 NET_47 VSS VSS N33 l=0.350u w=3.400u
M84 VSS NET_67 NET_47 VSS N33 l=0.350u w=5.330u
M85 VSS NET_67 NET_47 VSS N33 l=0.350u w=5.330u
M86 NET_47 NET_67 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_63 NET_48 VSS N33 l=0.350u w=5.330u
M88 NET_48 NET_63 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_63 NET_48 VSS N33 l=0.350u w=5.330u
M90 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M91 NET_58 OEN VSS VSS N33 l=0.350u w=7.440u
M92 VSS NET_69 NET_56 VSS N33 l=0.350u w=7.440u
M93 NET_56 NET_69 VSS VSS N33 l=0.350u w=7.440u
M94 NET_61 NET_3499 NET_59 VSS N33 l=0.350u w=8.000u
M95 NET_61 NET_58 VSS VSS N33 l=0.350u w=8.000u
M96 NET_85 NET_77 VSS VSS N33 l=0.350u w=8.000u
M97 VSS NET_72 NET_10 VSS N33 l=0.350u w=8.000u
M98 VSS NET_72 NET_10 VSS N33 l=0.350u w=8.000u
M99 VSS REN NET_89 VSS N33 l=0.350u w=8.000u
M100 VSS NET_82 NET_90 VSS N33 l=0.350u w=8.000u
M101 NET_40 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M102 NET_40 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M103 NET_92 VDD33 NET_40 VSS N33 l=0.350u w=8.000u
M104 VSS NET_92 NET_96 VSS N33 l=0.350u w=8.000u
M105 VDD NET_89 NET_116 VSS N33 l=0.350u w=4.000u
M106 VSS NET_96 NET_110 VSS N33 l=0.350u w=2.000u
M107 VSS NET_96 NET_110 VSS N33 l=0.350u w=2.000u
M108 VDD33 NET_89 NET_116 VDD33 P33 l=0.300u w=5.000u
M109 NET_5930 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M110 NET_5930 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M111 NET_5934 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M112 NET_5934 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M113 VDD33 NET_116 NET_40 NET_1369 P33 l=1.070u w=5.000u
M114 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M115 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M116 NET_110 NET_96 VDD VDD P33 l=0.300u w=5.000u
M117 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M118 NET_96 NET_92 NET_3534 VDD33 P33 l=0.300u w=5.000u
M119 NET_96 NET_92 NET_3534 VDD33 P33 l=0.300u w=5.000u
M120 NET_3534 NET_92 NET_96 VDD33 P33 l=0.300u w=5.000u
M121 NET_96 NET_92 NET_3534 VDD33 P33 l=0.300u w=5.000u
M122 NET_3534 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_40 NET_3534 VDD33 P33 l=0.300u w=5.000u
M124 NET_3534 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 PAD NET_59 NET_5918 NET_1369 P33 l=0.300u w=30.000u
M126 VDD33 NET_3499 NET_5918 NET_1369 P33 l=0.300u w=30.000u
M127 VDD33 NET_3499 NET_5916 NET_1369 P33 l=0.300u w=30.000u
M128 NET_5916 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M129 PAD NET_59 NET_5928 NET_1369 P33 l=0.300u w=30.000u
M130 VDD33 NET_3499 NET_5928 NET_1369 P33 l=0.300u w=30.000u
M131 VDD33 NET_3499 NET_5927 NET_1369 P33 l=0.300u w=30.000u
M132 NET_5927 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M133 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M134 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M135 NET_110 NET_96 VDD VDD P33 l=0.300u w=5.000u
M136 VDD NET_96 NET_110 VDD P33 l=0.300u w=5.000u
M137 PAD NET_59 NET_5914 NET_1369 P33 l=0.300u w=30.000u
M138 PAD NET_59 NET_5925 NET_1369 P33 l=0.300u w=30.000u
M139 VDD33 NET_89 NET_90 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_90 NET_89 VDD33 P33 l=0.300u w=5.000u
M141 NET_86 NET_10 VDD33 VDD33 P33 l=0.300u w=3.600u
M142 NET_5913 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M143 NET_5913 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M144 PAD NET_59 NET_5911 NET_1369 P33 l=0.300u w=30.000u
M145 NET_5924 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M146 NET_5924 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M147 PAD NET_59 NET_5907 NET_1369 P33 l=0.300u w=30.000u
M148 NET_5914 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M149 NET_5925 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M150 VDD33 NET_46 NET_5909 NET_1369 P33 l=0.300u w=30.000u
M151 NET_5909 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M152 VDD33 NET_46 NET_5919 NET_1369 P33 l=0.300u w=30.000u
M153 NET_5919 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M154 VDD33 VSS NET_3499 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_10 NET_85 VDD33 P33 l=0.300u w=5.000u
M156 NET_5890 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M157 NET_5890 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M158 NET_5904 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M159 NET_5904 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M160 NET_10 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_58 NET_56 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_56 NET_58 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_46 NET_5888 NET_1369 P33 l=0.300u w=30.000u
M164 NET_5888 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M165 PAD NET_59 NET_5886 NET_1369 P33 l=0.300u w=30.000u
M166 VDD33 NET_46 NET_5902 NET_1369 P33 l=0.300u w=30.000u
M167 NET_5902 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M168 PAD NET_59 NET_5901 NET_1369 P33 l=0.300u w=30.000u
M169 NET_5885 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M170 NET_5900 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M171 NET_5886 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M172 NET_5901 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M173 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M174 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M175 NET_46 NET_47 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_47 NET_46 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_47 NET_48 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M179 PAD NET_59 NET_5883 NET_1369 P33 l=0.300u w=30.000u
M180 NET_5883 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M181 PAD NET_59 NET_5898 NET_1369 P33 l=0.300u w=30.000u
M182 NET_5898 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M183 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M184 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M185 VDD33 PAD NET_1369 NET_1369 P33 l=0.350u w=5.000u
M186 VDD33 NET_40 NET_3534 VDD33 P33 l=0.300u w=5.000u
M187 NET_5911 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M188 NET_5907 NET_46 VDD33 NET_1369 P33 l=0.300u w=30.000u
M189 NET_5885 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M190 NET_5900 NET_59 PAD NET_1369 P33 l=0.300u w=30.000u
M191 PAD VDD33 NET_1369 NET_1369 P33 l=0.350u w=15.000u
M192 PAD VDD33 NET_59 NET_1369 P33 l=0.350u w=10.000u
R1 PAD NET_40 300.135
.ends PBCUL16

.subckt PBCUL12   PAD OEN I C REN FP
M1 VSS REN NET_98 VSS N18 l=0.180u w=2.000u
M2 VSS NET_108 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_108 C VSS N18 l=0.180u w=2.000u
M4 C NET_108 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_108 C VSS N18 l=0.180u w=2.000u
M6 C NET_108 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_108 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_111 NET_108 VSS N18 l=0.180u w=2.000u
M9 VSS NET_111 NET_108 VSS N18 l=0.180u w=2.000u
M10 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M11 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M12 NET_69 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_69 NET_70 NET_68 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M18 NET_73 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_73 VSS N18 l=0.180u w=2.000u
M20 NET_78 NET_73 VSS VSS N18 l=0.180u w=2.000u
M21 VSS NET_73 NET_78 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_98 VSS N18 l=0.180u w=2.000u
M23 VDD NET_108 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_111 NET_108 VDD P18 l=0.180u w=5.000u
M25 VDD NET_111 NET_108 VDD P18 l=0.180u w=5.000u
M26 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M27 VDD REN NET_98 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_98 VDD P18 l=0.180u w=5.000u
M29 VDD NET_108 C VDD P18 l=0.180u w=5.000u
M30 VDD NET_108 C VDD P18 l=0.180u w=5.000u
M31 VDD NET_108 C VDD P18 l=0.180u w=5.000u
M32 C NET_108 VDD VDD P18 l=0.180u w=5.000u
M33 VDD NET_108 C VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M36 NET_5996 OEN NET_73 VDD P18 l=0.180u w=5.000u
M37 NET_5996 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M39 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M40 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M41 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M42 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M43 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M44 VDD NET_70 NET_68 VDD P18 l=0.180u w=5.000u
M45 NET_68 NET_70 VDD VDD P18 l=0.180u w=5.000u
M46 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M47 NET_42 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_32 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_86 NET_30 VSSD N33 l=0.400u w=28.000u
M52 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M54 NET_28 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_44 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_39 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_86 NET_37 VSSD N33 l=0.400u w=28.000u
M60 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M62 NET_35 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M64 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M67 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M68 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M69 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M70 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M74 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M75 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M76 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M77 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M78 VSSD NET_24 NET_26 VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_33 VSSD N33 l=0.400u w=28.000u
M80 NET_85 NET_78 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_10 NET_86 VSS N33 l=0.350u w=8.000u
M82 VSS NET_10 NET_86 VSS N33 l=0.350u w=8.000u
M83 VSS NET_48 NET_45 VSS N33 l=0.350u w=5.000u
M84 VSS NET_48 NET_45 VSS N33 l=0.350u w=5.000u
M85 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M86 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M87 NET_48 NET_68 VSS VSS N33 l=0.350u w=5.330u
M88 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M89 NET_49 NET_64 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M91 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M92 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M93 VSS NET_70 NET_57 VSS N33 l=0.350u w=7.440u
M94 NET_57 NET_70 VSS VSS N33 l=0.350u w=7.440u
M95 NET_62 NET_3500 NET_60 VSS N33 l=0.350u w=8.000u
M96 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M97 NET_85 NET_78 VSS VSS N33 l=0.350u w=8.000u
M98 VSS NET_73 NET_10 VSS N33 l=0.350u w=8.000u
M99 VSS NET_73 NET_10 VSS N33 l=0.350u w=8.000u
M100 VSS REN NET_89 VSS N33 l=0.350u w=8.000u
M101 VSS NET_98 NET_90 VSS N33 l=0.350u w=8.000u
M102 NET_40 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M103 NET_40 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M104 NET_92 VDD33 NET_40 VSS N33 l=0.350u w=8.000u
M105 VSS NET_92 NET_96 VSS N33 l=0.350u w=8.000u
M106 VDD NET_89 NET_117 VSS N33 l=0.350u w=4.000u
M107 VSS NET_96 NET_111 VSS N33 l=0.350u w=2.000u
M108 VSS NET_96 NET_111 VSS N33 l=0.350u w=2.000u
M109 VDD33 NET_89 NET_117 VDD33 P33 l=0.300u w=5.000u
M110 NET_5965 NET_3500 VDD33 NET_1370 P33 l=0.300u w=30.000u
M111 NET_5965 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M112 NET_5969 NET_3500 VDD33 NET_1370 P33 l=0.300u w=30.000u
M113 NET_5969 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M114 VDD33 NET_117 NET_40 NET_1370 P33 l=1.070u w=5.000u
M115 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M116 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M117 NET_111 NET_96 VDD VDD P33 l=0.300u w=5.000u
M118 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M119 NET_96 NET_92 NET_3538 VDD33 P33 l=0.300u w=5.000u
M120 NET_96 NET_92 NET_3538 VDD33 P33 l=0.300u w=5.000u
M121 NET_3538 NET_92 NET_96 VDD33 P33 l=0.300u w=5.000u
M122 NET_96 NET_92 NET_3538 VDD33 P33 l=0.300u w=5.000u
M123 NET_3538 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_40 NET_3538 VDD33 P33 l=0.300u w=5.000u
M125 NET_3538 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 PAD NET_60 NET_5959 NET_1370 P33 l=0.300u w=30.000u
M127 VDD33 NET_3500 NET_5959 NET_1370 P33 l=0.300u w=30.000u
M128 VDD33 NET_3500 NET_5957 NET_1370 P33 l=0.300u w=30.000u
M129 NET_5957 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M130 PAD NET_60 NET_5963 NET_1370 P33 l=0.300u w=30.000u
M131 VDD33 NET_3500 NET_5963 NET_1370 P33 l=0.300u w=30.000u
M132 VDD33 NET_3500 NET_5962 NET_1370 P33 l=0.300u w=30.000u
M133 NET_5962 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M134 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M135 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M136 NET_111 NET_96 VDD VDD P33 l=0.300u w=5.000u
M137 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M138 PAD NET_60 NET_5955 NET_1370 P33 l=0.300u w=30.000u
M139 PAD NET_60 NET_5960 NET_1370 P33 l=0.300u w=30.000u
M140 VDD33 NET_89 NET_90 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_90 NET_89 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_10 NET_86 VDD33 P33 l=0.300u w=4.800u
M143 VDD33 NET_10 NET_86 VDD33 P33 l=0.300u w=4.800u
M144 NET_5949 NET_3500 VDD33 NET_1370 P33 l=0.300u w=30.000u
M145 NET_5949 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M146 PAD NET_60 NET_5947 NET_1370 P33 l=0.300u w=30.000u
M147 NET_5953 NET_3500 VDD33 NET_1370 P33 l=0.300u w=30.000u
M148 NET_5953 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M149 PAD NET_60 NET_5944 NET_1370 P33 l=0.300u w=30.000u
M150 NET_5955 NET_3500 VDD33 NET_1370 P33 l=0.300u w=30.000u
M151 NET_5960 NET_3500 VDD33 NET_1370 P33 l=0.300u w=30.000u
M152 VDD33 NET_45 NET_5945 NET_1370 P33 l=0.300u w=30.000u
M153 NET_5945 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M154 VDD33 NET_45 NET_5950 NET_1370 P33 l=0.300u w=30.000u
M155 NET_5950 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M156 VDD33 VSS NET_3500 VDD33 P33 l=0.300u w=5.000u
M157 VDD33 NET_10 NET_85 VDD33 P33 l=0.300u w=5.000u
M158 NET_5939 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M159 NET_5939 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M160 NET_5943 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M161 NET_5943 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M162 NET_10 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_45 NET_5937 NET_1370 P33 l=0.300u w=30.000u
M166 NET_5937 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M167 PAD NET_60 NET_5935 NET_1370 P33 l=0.300u w=30.000u
M168 VDD33 NET_45 NET_5941 NET_1370 P33 l=0.300u w=30.000u
M169 NET_5941 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M170 PAD NET_60 NET_5940 NET_1370 P33 l=0.300u w=30.000u
M171 NET_5925 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M172 NET_5933 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M173 NET_5935 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M174 NET_5940 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M175 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M177 NET_45 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M181 PAD NET_60 NET_5923 NET_1370 P33 l=0.300u w=30.000u
M182 NET_5923 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M183 PAD NET_60 NET_5931 NET_1370 P33 l=0.300u w=30.000u
M184 NET_5931 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M185 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M186 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M187 VDD33 PAD NET_1370 NET_1370 P33 l=0.350u w=5.000u
M188 VDD33 NET_40 NET_3538 VDD33 P33 l=0.300u w=5.000u
M189 NET_5947 NET_3500 VDD33 NET_1370 P33 l=0.300u w=30.000u
M190 NET_5944 NET_3500 VDD33 NET_1370 P33 l=0.300u w=30.000u
M191 NET_5925 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M192 NET_5933 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M193 PAD VDD33 NET_1370 NET_1370 P33 l=0.350u w=15.000u
M194 PAD VDD33 NET_60 NET_1370 P33 l=0.350u w=10.000u
R1 PAD NET_40 300.135
.ends PBCUL12

.subckt PBCU8   PAD OEN I C REN FP
M1 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M2 VSS NET_95 NET_85 VSS N18 l=0.180u w=2.000u
M3 VSS NET_95 NET_85 VSS N18 l=0.180u w=2.000u
M4 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M5 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M6 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M8 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M9 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_46 VSS N18 l=0.180u w=2.000u
M11 VSS OEN NET_46 VSS N18 l=0.180u w=2.000u
M12 NET_46 I VSS VSS N18 l=0.180u w=2.000u
M13 VSS I NET_46 VSS N18 l=0.180u w=2.000u
M14 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M15 VSS NET_55 NET_51 VSS N18 l=0.180u w=4.000u
M16 VSS NET_55 NET_51 VSS N18 l=0.180u w=4.000u
M17 NET_56 I VSS VSS N18 l=0.180u w=4.000u
M18 NET_56 NET_57 NET_55 VSS N18 l=0.180u w=4.000u
M19 VSS OEN NET_57 VSS N18 l=0.180u w=2.000u
M20 VSS OEN NET_57 VSS N18 l=0.180u w=2.000u
M21 NET_60 NET_46 VSS VSS N18 l=0.180u w=2.000u
M22 VSS NET_46 NET_60 VSS N18 l=0.180u w=2.000u
M23 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_95 NET_85 VDD P18 l=0.180u w=5.000u
M25 VDD NET_95 NET_85 VDD P18 l=0.180u w=5.000u
M26 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M27 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M29 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M30 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M31 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M32 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M33 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_57 VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_57 VDD P18 l=0.180u w=5.000u
M36 NET_6019 OEN NET_46 VDD P18 l=0.180u w=5.000u
M37 NET_6019 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M39 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M40 VDD NET_55 NET_51 VDD P18 l=0.180u w=5.000u
M41 VDD NET_55 NET_51 VDD P18 l=0.180u w=5.000u
M42 NET_55 I VDD VDD P18 l=0.180u w=5.000u
M43 NET_55 I VDD VDD P18 l=0.180u w=5.000u
M44 VDD NET_57 NET_55 VDD P18 l=0.180u w=5.000u
M45 NET_55 NET_57 VDD VDD P18 l=0.180u w=5.000u
M46 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M47 NET_42 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_32 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_24 NET_30 VSSD N33 l=0.400u w=28.000u
M52 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M54 NET_28 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_44 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_39 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_24 NET_37 VSSD N33 l=0.400u w=28.000u
M60 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M62 NET_35 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M64 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_17 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 VSSD NET_24 NET_15 VSSD N33 l=0.400u w=28.000u
M67 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M68 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M69 NET_13 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M70 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_23 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_24 NET_21 VSSD N33 l=0.400u w=28.000u
M74 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M75 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M76 NET_19 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M77 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M78 VSSD NET_24 NET_26 VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_33 VSSD N33 l=0.400u w=28.000u
M80 NET_102 NET_60 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_10 NET_103 VSS N33 l=0.350u w=8.000u
M82 VSS NET_10 NET_103 VSS N33 l=0.350u w=8.000u
M83 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M84 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M85 VSS NET_55 NET_67 VSS N33 l=0.350u w=5.330u
M86 VSS NET_55 NET_67 VSS N33 l=0.350u w=5.330u
M87 NET_67 NET_55 VSS VSS N33 l=0.350u w=5.330u
M88 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M89 NET_68 NET_51 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M91 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M92 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M93 VSS NET_57 NET_76 VSS N33 l=0.350u w=7.440u
M94 NET_76 NET_57 VSS VSS N33 l=0.350u w=7.440u
M95 NET_81 NET_3504 NET_79 VSS N33 l=0.350u w=8.000u
M96 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M97 NET_102 NET_60 VSS VSS N33 l=0.350u w=8.000u
M98 VSS NET_46 NET_10 VSS N33 l=0.350u w=8.000u
M99 VSS NET_46 NET_10 VSS N33 l=0.350u w=8.000u
M100 VSS REN NET_106 VSS N33 l=0.350u w=8.000u
M101 VSS NET_82 NET_107 VSS N33 l=0.350u w=8.000u
M102 NET_40 VDD33 NET_109 VSS N33 l=0.350u w=8.000u
M103 NET_40 VDD33 NET_109 VSS N33 l=0.350u w=8.000u
M104 NET_109 VDD33 NET_40 VSS N33 l=0.350u w=8.000u
M105 VSS NET_109 NET_113 VSS N33 l=0.350u w=8.000u
M106 VDD NET_106 NET_117 VSS N33 l=0.350u w=4.000u
M107 VSS NET_113 NET_95 VSS N33 l=0.350u w=2.000u
M108 VSS NET_113 NET_95 VSS N33 l=0.350u w=2.000u
M109 VDD33 NET_106 NET_117 VDD33 P33 l=0.300u w=5.000u
M110 NET_5989 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M111 NET_5989 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M112 NET_5993 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M113 NET_5993 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M114 VDD33 NET_117 NET_40 NET_1370 P33 l=1.070u w=5.000u
M115 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M116 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M117 NET_95 NET_113 VDD VDD P33 l=0.300u w=5.000u
M118 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M119 NET_113 NET_109 NET_3534 VDD33 P33 l=0.300u w=5.000u
M120 NET_113 NET_109 NET_3534 VDD33 P33 l=0.300u w=5.000u
M121 NET_3534 NET_109 NET_113 VDD33 P33 l=0.300u w=5.000u
M122 NET_113 NET_109 NET_3534 VDD33 P33 l=0.300u w=5.000u
M123 NET_3534 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_40 NET_3534 VDD33 P33 l=0.300u w=5.000u
M125 NET_3534 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 PAD NET_79 NET_5983 NET_1370 P33 l=0.300u w=30.000u
M127 VDD33 NET_3504 NET_5983 NET_1370 P33 l=0.300u w=30.000u
M128 VDD33 NET_3504 NET_5981 NET_1370 P33 l=0.300u w=30.000u
M129 NET_5981 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M130 PAD NET_79 NET_5987 NET_1370 P33 l=0.300u w=30.000u
M131 VDD33 NET_3504 NET_5987 NET_1370 P33 l=0.300u w=30.000u
M132 VDD33 NET_3504 NET_5986 NET_1370 P33 l=0.300u w=30.000u
M133 NET_5986 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M134 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M135 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M136 NET_95 NET_113 VDD VDD P33 l=0.300u w=5.000u
M137 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M138 PAD NET_79 NET_5979 NET_1370 P33 l=0.300u w=30.000u
M139 PAD NET_79 NET_5984 NET_1370 P33 l=0.300u w=30.000u
M140 NET_103 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 NET_103 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_106 NET_107 VDD33 P33 l=0.300u w=5.000u
M143 VDD33 NET_107 NET_106 VDD33 P33 l=0.300u w=5.000u
M144 NET_5973 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M145 NET_5973 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M146 PAD NET_79 NET_5971 NET_1370 P33 l=0.300u w=30.000u
M147 NET_5977 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M148 NET_5977 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M149 PAD NET_79 NET_5968 NET_1370 P33 l=0.300u w=30.000u
M150 NET_5979 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M151 NET_5984 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M152 VDD33 NET_10 NET_103 VDD33 P33 l=0.300u w=5.000u
M153 NET_103 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_3504 NET_5969 NET_1370 P33 l=0.300u w=30.000u
M155 NET_5969 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M156 VDD33 NET_3504 NET_5974 NET_1370 P33 l=0.300u w=30.000u
M157 NET_5974 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M158 VDD33 VSS NET_3504 VDD33 P33 l=0.300u w=5.000u
M159 VDD33 NET_10 NET_102 VDD33 P33 l=0.300u w=5.000u
M160 NET_5963 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M161 NET_5963 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M162 NET_5967 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M163 NET_5967 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M164 NET_10 NET_102 VDD33 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_64 NET_5961 NET_1370 P33 l=0.300u w=30.000u
M168 NET_5961 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M169 PAD NET_79 NET_5959 NET_1370 P33 l=0.300u w=30.000u
M170 VDD33 NET_64 NET_5965 NET_1370 P33 l=0.300u w=30.000u
M171 NET_5965 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M172 PAD NET_79 NET_5964 NET_1370 P33 l=0.300u w=30.000u
M173 NET_5949 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M174 NET_5957 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M175 NET_5959 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M176 NET_5964 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M177 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M178 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M181 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M182 PAD NET_79 NET_5947 NET_1370 P33 l=0.300u w=30.000u
M183 NET_5947 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M184 PAD NET_79 NET_5955 NET_1370 P33 l=0.300u w=30.000u
M185 NET_5955 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M186 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M187 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M188 VDD33 PAD NET_1370 NET_1370 P33 l=0.350u w=5.000u
M189 VDD33 NET_40 NET_3534 VDD33 P33 l=0.300u w=5.000u
M190 NET_5971 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M191 NET_5968 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M192 NET_5949 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M193 NET_5957 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M194 PAD VDD33 NET_1370 NET_1370 P33 l=0.350u w=15.000u
M195 PAD VDD33 NET_79 NET_1370 P33 l=0.350u w=10.000u
R1 PAD NET_40 300.135
.ends PBCU8

.subckt PBCU4   PAD OEN I C REN FP
M1 VSS REN NET_99 VSS N18 l=0.180u w=2.000u
M2 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M4 C NET_109 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M6 C NET_109 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_112 NET_109 VSS N18 l=0.180u w=2.000u
M9 VSS NET_112 NET_109 VSS N18 l=0.180u w=2.000u
M10 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M11 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M12 NET_69 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_69 NET_70 NET_68 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M18 NET_73 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_73 VSS N18 l=0.180u w=2.000u
M20 NET_78 NET_73 VSS VSS N18 l=0.180u w=2.000u
M21 VSS NET_73 NET_78 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_99 VSS N18 l=0.180u w=2.000u
M23 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_112 NET_109 VDD P18 l=0.180u w=5.000u
M25 VDD NET_112 NET_109 VDD P18 l=0.180u w=5.000u
M26 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M27 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_99 VDD P18 l=0.180u w=5.000u
M29 VDD REN NET_99 VDD P18 l=0.180u w=5.000u
M30 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M31 C NET_109 VDD VDD P18 l=0.180u w=5.000u
M32 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M33 C NET_109 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M36 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M37 NET_6001 OEN NET_73 VDD P18 l=0.180u w=5.000u
M38 NET_6001 I VDD VDD P18 l=0.180u w=5.000u
M39 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M40 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M41 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M42 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M43 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_70 NET_68 VDD P18 l=0.180u w=5.000u
M46 NET_68 NET_70 VDD VDD P18 l=0.180u w=5.000u
M47 NET_42 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_32 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_24 NET_30 VSSD N33 l=0.400u w=28.000u
M52 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M54 NET_28 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_44 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_39 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_24 NET_37 VSSD N33 l=0.400u w=28.000u
M60 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M62 NET_35 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_24 NET_26 VSSD N33 l=0.400u w=28.000u
M64 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_17 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_15 VSSD N33 l=0.400u w=28.000u
M68 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M70 NET_13 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_33 VSSD N33 l=0.400u w=28.000u
M72 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M73 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M74 NET_23 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_21 VSSD N33 l=0.400u w=28.000u
M76 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M77 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M78 NET_19 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M80 NET_87 NET_10 VSS VSS N33 l=0.350u w=4.000u
M81 NET_87 NET_10 VSS VSS N33 l=0.350u w=4.000u
M82 VSS NET_10 NET_87 VSS N33 l=0.350u w=4.000u
M83 VSS REN NET_90 VSS N33 l=0.350u w=8.000u
M84 VSS NET_99 NET_91 VSS N33 l=0.350u w=8.000u
M85 NET_40 VDD33 NET_93 VSS N33 l=0.350u w=8.000u
M86 NET_40 VDD33 NET_93 VSS N33 l=0.350u w=8.000u
M87 NET_93 VDD33 NET_40 VSS N33 l=0.350u w=8.000u
M88 VSS NET_93 NET_97 VSS N33 l=0.350u w=8.000u
M89 VDD NET_90 NET_118 VSS N33 l=0.350u w=4.000u
M90 VSS NET_97 NET_112 VSS N33 l=0.350u w=2.000u
M91 VSS NET_97 NET_112 VSS N33 l=0.350u w=2.000u
M92 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M93 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M94 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M95 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M96 NET_48 NET_68 VSS VSS N33 l=0.350u w=5.330u
M97 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M98 NET_49 NET_64 VSS VSS N33 l=0.350u w=5.330u
M99 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M100 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M101 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M102 VSS NET_70 NET_57 VSS N33 l=0.350u w=7.440u
M103 NET_57 NET_70 VSS VSS N33 l=0.350u w=7.440u
M104 NET_62 NET_3514 NET_60 VSS N33 l=0.350u w=8.000u
M105 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M106 NET_85 NET_78 VSS VSS N33 l=0.350u w=8.000u
M107 VSS NET_73 NET_10 VSS N33 l=0.350u w=8.000u
M108 VSS NET_73 NET_10 VSS N33 l=0.350u w=8.000u
M109 NET_85 NET_78 VSS VSS N33 l=0.350u w=8.000u
M110 VDD33 NET_90 NET_118 VDD33 P33 l=0.300u w=5.000u
M111 NET_5972 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M112 NET_5972 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M113 NET_5976 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M114 NET_5976 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M115 VDD33 NET_118 NET_40 NET_1371 P33 l=1.070u w=5.000u
M116 VDD NET_97 NET_112 VDD P33 l=0.300u w=5.000u
M117 VDD NET_97 NET_112 VDD P33 l=0.300u w=5.000u
M118 NET_112 NET_97 VDD VDD P33 l=0.300u w=5.000u
M119 VDD NET_97 NET_112 VDD P33 l=0.300u w=5.000u
M120 NET_97 NET_93 NET_3543 VDD33 P33 l=0.300u w=5.000u
M121 NET_97 NET_93 NET_3543 VDD33 P33 l=0.300u w=5.000u
M122 NET_3543 NET_93 NET_97 VDD33 P33 l=0.300u w=5.000u
M123 NET_97 NET_93 NET_3543 VDD33 P33 l=0.300u w=5.000u
M124 NET_3543 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 VDD33 NET_40 NET_3543 VDD33 P33 l=0.300u w=5.000u
M126 NET_3543 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M127 PAD NET_60 NET_5960 NET_1371 P33 l=0.300u w=30.000u
M128 VDD33 NET_3514 NET_5960 NET_1371 P33 l=0.300u w=30.000u
M129 VDD33 NET_3514 NET_5958 NET_1371 P33 l=0.300u w=30.000u
M130 NET_5958 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M131 PAD NET_60 NET_5970 NET_1371 P33 l=0.300u w=30.000u
M132 VDD33 NET_3514 NET_5970 NET_1371 P33 l=0.300u w=30.000u
M133 VDD33 NET_3514 NET_5969 NET_1371 P33 l=0.300u w=30.000u
M134 NET_5969 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M135 VDD NET_97 NET_112 VDD P33 l=0.300u w=5.000u
M136 VDD NET_97 NET_112 VDD P33 l=0.300u w=5.000u
M137 NET_112 NET_97 VDD VDD P33 l=0.300u w=5.000u
M138 VDD NET_97 NET_112 VDD P33 l=0.300u w=5.000u
M139 PAD NET_60 NET_5956 NET_1371 P33 l=0.300u w=30.000u
M140 PAD NET_60 NET_5967 NET_1371 P33 l=0.300u w=30.000u
M141 NET_87 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 NET_87 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M143 VDD33 NET_90 NET_91 VDD33 P33 l=0.300u w=5.000u
M144 VDD33 NET_91 NET_90 VDD33 P33 l=0.300u w=5.000u
M145 NET_5955 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M146 NET_5955 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M147 PAD NET_60 NET_5953 NET_1371 P33 l=0.300u w=30.000u
M148 NET_5966 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M149 NET_5966 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M150 PAD NET_60 NET_5949 NET_1371 P33 l=0.300u w=30.000u
M151 NET_5956 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M152 NET_5967 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M153 VDD33 NET_10 NET_87 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_3514 NET_5951 NET_1371 P33 l=0.300u w=30.000u
M155 NET_5951 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M156 VDD33 NET_3514 NET_5961 NET_1371 P33 l=0.300u w=30.000u
M157 NET_5961 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M158 VDD33 VSS NET_3514 VDD33 P33 l=0.300u w=5.000u
M159 VDD33 NET_10 NET_85 VDD33 P33 l=0.300u w=5.000u
M160 NET_5932 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M161 NET_5932 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M162 NET_5946 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M163 NET_5946 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M164 NET_10 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_3514 NET_5930 NET_1371 P33 l=0.300u w=30.000u
M168 NET_5930 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M169 PAD NET_60 NET_5928 NET_1371 P33 l=0.300u w=30.000u
M170 VDD33 NET_3514 NET_5944 NET_1371 P33 l=0.300u w=30.000u
M171 NET_5944 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M172 PAD NET_60 NET_5943 NET_1371 P33 l=0.300u w=30.000u
M173 NET_5927 NET_45 VDD33 NET_1371 P33 l=0.300u w=30.000u
M174 NET_5942 NET_45 VDD33 NET_1371 P33 l=0.300u w=30.000u
M175 NET_5928 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M176 NET_5943 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M177 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M181 PAD NET_60 NET_5925 NET_1371 P33 l=0.300u w=30.000u
M182 NET_5925 NET_45 VDD33 NET_1371 P33 l=0.300u w=30.000u
M183 PAD NET_60 NET_5940 NET_1371 P33 l=0.300u w=30.000u
M184 NET_5940 NET_45 VDD33 NET_1371 P33 l=0.300u w=30.000u
M185 NET_1371 PAD VDD33 NET_1371 P33 l=0.350u w=5.000u
M186 NET_1371 PAD VDD33 NET_1371 P33 l=0.350u w=5.000u
M187 VDD33 PAD NET_1371 NET_1371 P33 l=0.350u w=5.000u
M188 VDD33 NET_40 NET_3543 VDD33 P33 l=0.300u w=5.000u
M189 NET_5953 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M190 NET_5949 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M191 NET_5927 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M192 NET_5942 NET_60 PAD NET_1371 P33 l=0.300u w=30.000u
M193 PAD VDD33 NET_1371 NET_1371 P33 l=0.350u w=15.000u
M194 PAD VDD33 NET_60 NET_1371 P33 l=0.350u w=10.000u
R1 PAD NET_40 300.135
.ends PBCU4

.subckt PBCU24   PAD OEN I C REN FP
M1 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M2 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M4 C NET_92 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M6 C NET_92 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_92 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_95 NET_92 VSS N18 l=0.180u w=2.000u
M9 VSS NET_95 NET_92 VSS N18 l=0.180u w=2.000u
M10 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M11 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M12 NET_51 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_51 NET_52 NET_50 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M18 NET_55 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_55 VSS N18 l=0.180u w=2.000u
M20 NET_60 NET_55 VSS VSS N18 l=0.180u w=2.000u
M21 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M23 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_95 NET_92 VDD P18 l=0.180u w=5.000u
M25 VDD NET_95 NET_92 VDD P18 l=0.180u w=5.000u
M26 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M27 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M29 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M30 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M31 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M32 C NET_92 VDD VDD P18 l=0.180u w=5.000u
M33 VDD NET_92 C VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M36 NET_6019 OEN NET_55 VDD P18 l=0.180u w=5.000u
M37 NET_6019 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M39 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M40 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M41 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M42 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M43 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_52 NET_50 VDD P18 l=0.180u w=5.000u
M46 NET_50 NET_52 VDD VDD P18 l=0.180u w=5.000u
M47 NET_41 NET_104 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_31 NET_104 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_104 NET_29 VSSD N33 l=0.400u w=28.000u
M52 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M54 NET_27 NET_104 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_43 NET_104 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_38 NET_104 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_104 NET_36 VSSD N33 l=0.400u w=28.000u
M60 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M62 NET_34 NET_104 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M64 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M66 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M68 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M69 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M70 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_104 NET_32 VSSD N33 l=0.400u w=28.000u
M72 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M73 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M74 NET_22 NET_104 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_104 NET_20 VSSD N33 l=0.400u w=28.000u
M76 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M77 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M78 NET_18 NET_104 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M80 NET_104 NET_10 VSS VSS N33 l=0.350u w=8.000u
M81 NET_104 NET_10 VSS VSS N33 l=0.350u w=8.000u
M82 VSS NET_10 NET_104 VSS N33 l=0.350u w=8.000u
M83 VSS REN NET_107 VSS N33 l=0.350u w=8.000u
M84 VSS NET_82 NET_108 VSS N33 l=0.350u w=8.000u
M85 NET_44 VDD33 NET_110 VSS N33 l=0.350u w=8.000u
M86 NET_44 VDD33 NET_110 VSS N33 l=0.350u w=8.000u
M87 NET_110 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M88 VSS NET_110 NET_114 VSS N33 l=0.350u w=8.000u
M89 VDD NET_107 NET_118 VSS N33 l=0.350u w=4.000u
M90 VSS NET_114 NET_95 VSS N33 l=0.350u w=2.000u
M91 VSS NET_114 NET_95 VSS N33 l=0.350u w=2.000u
M92 VSS NET_67 NET_64 VSS N33 l=0.350u w=8.000u
M93 VSS NET_67 NET_64 VSS N33 l=0.350u w=8.000u
M94 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M95 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M96 NET_67 NET_50 VSS VSS N33 l=0.350u w=5.330u
M97 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M98 NET_68 NET_46 VSS VSS N33 l=0.350u w=5.330u
M99 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M100 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M101 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M102 VSS NET_52 NET_76 VSS N33 l=0.350u w=7.440u
M103 NET_76 NET_52 VSS VSS N33 l=0.350u w=7.440u
M104 NET_81 NET_3509 NET_79 VSS N33 l=0.350u w=8.000u
M105 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M106 NET_102 NET_60 VSS VSS N33 l=0.350u w=8.000u
M107 VSS NET_55 NET_10 VSS N33 l=0.350u w=8.000u
M108 VSS NET_55 NET_10 VSS N33 l=0.350u w=8.000u
M109 NET_102 NET_60 VSS VSS N33 l=0.350u w=8.000u
M110 NET_5987 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M111 NET_5987 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M112 NET_5991 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M113 NET_5991 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M114 VDD33 NET_118 NET_44 NET_1371 P33 l=1.070u w=5.000u
M115 VDD33 NET_107 NET_118 VDD33 P33 l=0.300u w=5.000u
M116 VDD NET_114 NET_95 VDD P33 l=0.300u w=5.000u
M117 VDD NET_114 NET_95 VDD P33 l=0.300u w=5.000u
M118 NET_95 NET_114 VDD VDD P33 l=0.300u w=5.000u
M119 VDD NET_114 NET_95 VDD P33 l=0.300u w=5.000u
M120 PAD NET_79 NET_5981 NET_1371 P33 l=0.300u w=30.000u
M121 VDD33 NET_64 NET_5981 NET_1371 P33 l=0.300u w=30.000u
M122 VDD33 NET_64 NET_5979 NET_1371 P33 l=0.300u w=30.000u
M123 NET_5979 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M124 PAD NET_79 NET_5985 NET_1371 P33 l=0.300u w=30.000u
M125 VDD33 NET_64 NET_5985 NET_1371 P33 l=0.300u w=30.000u
M126 VDD33 NET_64 NET_5984 NET_1371 P33 l=0.300u w=30.000u
M127 NET_5984 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M128 NET_114 NET_110 NET_3537 VDD33 P33 l=0.300u w=5.000u
M129 NET_114 NET_110 NET_3537 VDD33 P33 l=0.300u w=5.000u
M130 NET_3537 NET_110 NET_114 VDD33 P33 l=0.300u w=5.000u
M131 NET_114 NET_110 NET_3537 VDD33 P33 l=0.300u w=5.000u
M132 NET_3537 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M133 VDD33 NET_44 NET_3537 VDD33 P33 l=0.300u w=5.000u
M134 NET_3537 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M135 VDD NET_114 NET_95 VDD P33 l=0.300u w=5.000u
M136 VDD NET_114 NET_95 VDD P33 l=0.300u w=5.000u
M137 NET_95 NET_114 VDD VDD P33 l=0.300u w=5.000u
M138 VDD NET_114 NET_95 VDD P33 l=0.300u w=5.000u
M139 PAD NET_79 NET_5977 NET_1371 P33 l=0.300u w=30.000u
M140 PAD NET_79 NET_5982 NET_1371 P33 l=0.300u w=30.000u
M141 NET_5977 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M142 NET_5971 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M143 NET_5971 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M144 PAD NET_79 NET_5969 NET_1371 P33 l=0.300u w=30.000u
M145 NET_5982 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M146 NET_5975 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M147 NET_5975 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M148 PAD NET_79 NET_5966 NET_1371 P33 l=0.300u w=30.000u
M149 NET_104 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M150 NET_104 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M151 VDD33 NET_107 NET_108 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_108 NET_107 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_64 NET_5967 NET_1371 P33 l=0.300u w=30.000u
M154 NET_5967 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M155 VDD33 NET_64 NET_5972 NET_1371 P33 l=0.300u w=30.000u
M156 NET_5972 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M157 VDD33 NET_10 NET_104 VDD33 P33 l=0.300u w=5.000u
M158 NET_5961 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M159 NET_5961 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M160 NET_5965 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M161 NET_5965 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M162 VDD33 VSS NET_3509 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_10 NET_102 VDD33 P33 l=0.300u w=5.000u
M164 NET_10 NET_102 VDD33 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_64 NET_5959 NET_1371 P33 l=0.300u w=30.000u
M166 NET_5959 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M167 PAD NET_79 NET_5957 NET_1371 P33 l=0.300u w=30.000u
M168 VDD33 NET_64 NET_5963 NET_1371 P33 l=0.300u w=30.000u
M169 NET_5963 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M170 PAD NET_79 NET_5962 NET_1371 P33 l=0.300u w=30.000u
M171 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M172 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M173 NET_5957 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M174 NET_5947 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M175 NET_5962 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M176 NET_5955 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M177 PAD NET_79 NET_5945 NET_1371 P33 l=0.300u w=30.000u
M178 NET_5945 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M179 PAD NET_79 NET_5953 NET_1371 P33 l=0.300u w=30.000u
M180 NET_5953 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M181 NET_1371 PAD VDD33 NET_1371 P33 l=0.350u w=5.000u
M182 NET_1371 PAD VDD33 NET_1371 P33 l=0.350u w=5.000u
M183 VDD33 PAD NET_1371 NET_1371 P33 l=0.350u w=5.000u
M184 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M185 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M186 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M187 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M188 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M189 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M190 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M191 VDD33 NET_44 NET_3537 VDD33 P33 l=0.300u w=5.000u
M192 NET_5969 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M193 NET_5966 NET_64 VDD33 NET_1371 P33 l=0.300u w=30.000u
M194 NET_5947 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M195 NET_5955 NET_79 PAD NET_1371 P33 l=0.300u w=30.000u
M196 PAD VDD33 NET_1371 NET_1371 P33 l=0.350u w=15.000u
M197 PAD VDD33 NET_79 NET_1371 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBCU24

.subckt PBCU2   PAD OEN I C REN FP
M1 VSS REN NET_98 VSS N18 l=0.180u w=2.000u
M2 VSS NET_108 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_108 C VSS N18 l=0.180u w=2.000u
M4 C NET_108 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_108 C VSS N18 l=0.180u w=2.000u
M6 C NET_108 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_108 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_111 NET_108 VSS N18 l=0.180u w=2.000u
M9 VSS NET_111 NET_108 VSS N18 l=0.180u w=2.000u
M10 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M11 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M12 NET_69 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_69 NET_70 NET_68 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M18 NET_73 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_73 VSS N18 l=0.180u w=2.000u
M20 NET_78 NET_73 VSS VSS N18 l=0.180u w=2.000u
M21 VSS NET_73 NET_78 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_98 VSS N18 l=0.180u w=2.000u
M23 VDD NET_108 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_111 NET_108 VDD P18 l=0.180u w=5.000u
M25 VDD NET_111 NET_108 VDD P18 l=0.180u w=5.000u
M26 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M27 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_98 VDD P18 l=0.180u w=5.000u
M29 VDD REN NET_98 VDD P18 l=0.180u w=5.000u
M30 VDD NET_108 C VDD P18 l=0.180u w=5.000u
M31 C NET_108 VDD VDD P18 l=0.180u w=5.000u
M32 VDD NET_108 C VDD P18 l=0.180u w=5.000u
M33 C NET_108 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_108 C VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M36 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M37 NET_5991 OEN NET_73 VDD P18 l=0.180u w=5.000u
M38 NET_5991 I VDD VDD P18 l=0.180u w=5.000u
M39 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M40 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M41 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M42 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M43 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_70 NET_68 VDD P18 l=0.180u w=5.000u
M46 NET_68 NET_70 VDD VDD P18 l=0.180u w=5.000u
M47 NET_41 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M52 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M54 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_43 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M60 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M62 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M64 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M67 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M68 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M69 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M70 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M74 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M75 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M76 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M77 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M78 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M80 NET_85 NET_78 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_10 NET_86 VSS N33 l=0.350u w=4.000u
M82 VSS NET_10 NET_86 VSS N33 l=0.350u w=4.000u
M83 VSS NET_48 NET_45 VSS N33 l=0.350u w=4.000u
M84 VSS NET_48 NET_45 VSS N33 l=0.350u w=4.000u
M85 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M86 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M87 NET_48 NET_68 VSS VSS N33 l=0.350u w=5.330u
M88 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M89 NET_49 NET_64 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M91 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M92 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M93 VSS NET_70 NET_57 VSS N33 l=0.350u w=7.440u
M94 NET_57 NET_70 VSS VSS N33 l=0.350u w=7.440u
M95 NET_62 NET_3509 NET_60 VSS N33 l=0.350u w=8.000u
M96 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M97 NET_85 NET_78 VSS VSS N33 l=0.350u w=8.000u
M98 VSS NET_73 NET_10 VSS N33 l=0.350u w=8.000u
M99 VSS NET_73 NET_10 VSS N33 l=0.350u w=8.000u
M100 VSS REN NET_89 VSS N33 l=0.350u w=8.000u
M101 VSS NET_98 NET_90 VSS N33 l=0.350u w=8.000u
M102 NET_44 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M103 NET_44 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M104 NET_92 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M105 VSS NET_92 NET_96 VSS N33 l=0.350u w=8.000u
M106 VDD NET_89 NET_117 VSS N33 l=0.350u w=4.000u
M107 VSS NET_96 NET_111 VSS N33 l=0.350u w=2.000u
M108 VSS NET_96 NET_111 VSS N33 l=0.350u w=2.000u
M109 VDD33 NET_89 NET_117 VDD33 P33 l=0.300u w=5.000u
M110 NET_5961 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M111 NET_5961 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M112 NET_5965 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M113 NET_5965 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M114 VDD33 NET_117 NET_44 NET_1370 P33 l=1.070u w=5.000u
M115 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M116 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M117 NET_111 NET_96 VDD VDD P33 l=0.300u w=5.000u
M118 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M119 NET_96 NET_92 NET_3551 VDD33 P33 l=0.300u w=5.000u
M120 NET_96 NET_92 NET_3551 VDD33 P33 l=0.300u w=5.000u
M121 NET_3551 NET_92 NET_96 VDD33 P33 l=0.300u w=5.000u
M122 NET_96 NET_92 NET_3551 VDD33 P33 l=0.300u w=5.000u
M123 NET_3551 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_44 NET_3551 VDD33 P33 l=0.300u w=5.000u
M125 NET_3551 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 PAD NET_60 NET_5949 NET_1370 P33 l=0.300u w=30.000u
M127 VDD33 NET_3509 NET_5949 NET_1370 P33 l=0.300u w=30.000u
M128 VDD33 NET_3509 NET_5947 NET_1370 P33 l=0.300u w=30.000u
M129 NET_5947 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M130 PAD NET_60 NET_5959 NET_1370 P33 l=0.300u w=30.000u
M131 VDD33 NET_3509 NET_5959 NET_1370 P33 l=0.300u w=30.000u
M132 VDD33 NET_3509 NET_5958 NET_1370 P33 l=0.300u w=30.000u
M133 NET_5958 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M134 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M135 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M136 NET_111 NET_96 VDD VDD P33 l=0.300u w=5.000u
M137 VDD NET_96 NET_111 VDD P33 l=0.300u w=5.000u
M138 PAD NET_60 NET_5945 NET_1370 P33 l=0.300u w=30.000u
M139 PAD NET_60 NET_5956 NET_1370 P33 l=0.300u w=30.000u
M140 VDD33 NET_89 NET_90 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_90 NET_89 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_10 NET_86 VDD33 P33 l=0.300u w=5.000u
M143 NET_5944 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M144 NET_5944 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M145 PAD NET_60 NET_5942 NET_1370 P33 l=0.300u w=30.000u
M146 NET_5955 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M147 NET_5955 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M148 PAD NET_60 NET_5938 NET_1370 P33 l=0.300u w=30.000u
M149 NET_5945 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M150 NET_5956 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M151 VDD33 NET_3509 NET_5940 NET_1370 P33 l=0.300u w=30.000u
M152 NET_5940 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M153 VDD33 NET_3509 NET_5950 NET_1370 P33 l=0.300u w=30.000u
M154 NET_5950 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M155 VDD33 VSS NET_3509 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_10 NET_85 VDD33 P33 l=0.300u w=5.000u
M157 NET_5921 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M158 NET_5921 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M159 NET_5935 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M160 NET_5935 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M161 NET_10 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_3509 NET_5919 NET_1370 P33 l=0.300u w=30.000u
M165 NET_5919 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M166 PAD NET_60 NET_5917 NET_1370 P33 l=0.300u w=30.000u
M167 VDD33 NET_3509 NET_5933 NET_1370 P33 l=0.300u w=30.000u
M168 NET_5933 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M169 PAD NET_60 NET_5932 NET_1370 P33 l=0.300u w=30.000u
M170 NET_5916 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M171 NET_5931 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M172 NET_5917 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M173 NET_5932 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M174 NET_45 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M175 NET_45 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M179 PAD NET_60 NET_5914 NET_1370 P33 l=0.300u w=30.000u
M180 NET_5914 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M181 PAD NET_60 NET_5929 NET_1370 P33 l=0.300u w=30.000u
M182 NET_5929 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M183 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M184 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M185 VDD33 PAD NET_1370 NET_1370 P33 l=0.350u w=5.000u
M186 VDD33 NET_44 NET_3551 VDD33 P33 l=0.300u w=5.000u
M187 NET_5942 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M188 NET_5938 NET_3509 VDD33 NET_1370 P33 l=0.300u w=30.000u
M189 NET_5916 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M190 NET_5931 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M191 PAD VDD33 NET_1370 NET_1370 P33 l=0.350u w=15.000u
M192 PAD VDD33 NET_60 NET_1370 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBCU2

.subckt PBCU16   PAD OEN I C REN FP
M1 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M2 VSS NET_95 NET_85 VSS N18 l=0.180u w=2.000u
M3 VSS NET_95 NET_85 VSS N18 l=0.180u w=2.000u
M4 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M5 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M6 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M8 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M9 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_46 VSS N18 l=0.180u w=2.000u
M11 VSS OEN NET_46 VSS N18 l=0.180u w=2.000u
M12 NET_46 I VSS VSS N18 l=0.180u w=2.000u
M13 VSS I NET_46 VSS N18 l=0.180u w=2.000u
M14 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M15 VSS NET_55 NET_51 VSS N18 l=0.180u w=4.000u
M16 VSS NET_55 NET_51 VSS N18 l=0.180u w=4.000u
M17 NET_56 I VSS VSS N18 l=0.180u w=4.000u
M18 NET_56 NET_57 NET_55 VSS N18 l=0.180u w=4.000u
M19 VSS OEN NET_57 VSS N18 l=0.180u w=2.000u
M20 VSS OEN NET_57 VSS N18 l=0.180u w=2.000u
M21 NET_60 NET_46 VSS VSS N18 l=0.180u w=2.000u
M22 VSS NET_46 NET_60 VSS N18 l=0.180u w=2.000u
M23 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_95 NET_85 VDD P18 l=0.180u w=5.000u
M25 VDD NET_95 NET_85 VDD P18 l=0.180u w=5.000u
M26 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M27 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M29 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M30 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M31 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M32 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M33 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_57 VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_57 VDD P18 l=0.180u w=5.000u
M36 NET_6019 OEN NET_46 VDD P18 l=0.180u w=5.000u
M37 NET_6019 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M39 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M40 VDD NET_55 NET_51 VDD P18 l=0.180u w=5.000u
M41 VDD NET_55 NET_51 VDD P18 l=0.180u w=5.000u
M42 NET_55 I VDD VDD P18 l=0.180u w=5.000u
M43 NET_55 I VDD VDD P18 l=0.180u w=5.000u
M44 VDD NET_57 NET_55 VDD P18 l=0.180u w=5.000u
M45 NET_55 NET_57 VDD VDD P18 l=0.180u w=5.000u
M46 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M47 NET_42 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_32 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_103 NET_30 VSSD N33 l=0.400u w=28.000u
M52 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M54 NET_28 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_44 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_39 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_103 NET_37 VSSD N33 l=0.400u w=28.000u
M60 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M62 NET_35 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M63 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M64 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_17 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 VSSD NET_24 NET_15 VSSD N33 l=0.400u w=28.000u
M67 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M68 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M69 NET_13 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M70 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_23 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_24 NET_21 VSSD N33 l=0.400u w=28.000u
M74 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M75 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M76 NET_19 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M77 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M78 VSSD NET_24 NET_26 VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_33 VSSD N33 l=0.400u w=28.000u
M80 NET_102 NET_60 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_10 NET_103 VSS N33 l=0.350u w=8.000u
M82 VSS NET_10 NET_103 VSS N33 l=0.350u w=8.000u
M83 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M84 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M85 VSS NET_55 NET_67 VSS N33 l=0.350u w=5.330u
M86 VSS NET_55 NET_67 VSS N33 l=0.350u w=5.330u
M87 NET_67 NET_55 VSS VSS N33 l=0.350u w=5.330u
M88 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M89 NET_68 NET_51 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M91 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M92 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M93 VSS NET_57 NET_76 VSS N33 l=0.350u w=7.440u
M94 NET_76 NET_57 VSS VSS N33 l=0.350u w=7.440u
M95 NET_81 NET_3504 NET_79 VSS N33 l=0.350u w=8.000u
M96 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M97 NET_102 NET_60 VSS VSS N33 l=0.350u w=8.000u
M98 VSS NET_46 NET_10 VSS N33 l=0.350u w=8.000u
M99 VSS NET_46 NET_10 VSS N33 l=0.350u w=8.000u
M100 VSS REN NET_106 VSS N33 l=0.350u w=8.000u
M101 VSS NET_82 NET_107 VSS N33 l=0.350u w=8.000u
M102 NET_40 VDD33 NET_109 VSS N33 l=0.350u w=8.000u
M103 NET_40 VDD33 NET_109 VSS N33 l=0.350u w=8.000u
M104 NET_109 VDD33 NET_40 VSS N33 l=0.350u w=8.000u
M105 VSS NET_109 NET_113 VSS N33 l=0.350u w=8.000u
M106 VDD NET_106 NET_117 VSS N33 l=0.350u w=4.000u
M107 VSS NET_113 NET_95 VSS N33 l=0.350u w=2.000u
M108 VSS NET_113 NET_95 VSS N33 l=0.350u w=2.000u
M109 VDD33 NET_106 NET_117 VDD33 P33 l=0.300u w=5.000u
M110 NET_5989 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M111 NET_5989 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M112 NET_5993 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M113 NET_5993 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M114 VDD33 NET_117 NET_40 NET_1370 P33 l=1.070u w=5.000u
M115 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M116 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M117 NET_95 NET_113 VDD VDD P33 l=0.300u w=5.000u
M118 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M119 NET_113 NET_109 NET_3534 VDD33 P33 l=0.300u w=5.000u
M120 NET_113 NET_109 NET_3534 VDD33 P33 l=0.300u w=5.000u
M121 NET_3534 NET_109 NET_113 VDD33 P33 l=0.300u w=5.000u
M122 NET_113 NET_109 NET_3534 VDD33 P33 l=0.300u w=5.000u
M123 NET_3534 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_40 NET_3534 VDD33 P33 l=0.300u w=5.000u
M125 NET_3534 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 PAD NET_79 NET_5983 NET_1370 P33 l=0.300u w=30.000u
M127 VDD33 NET_3504 NET_5983 NET_1370 P33 l=0.300u w=30.000u
M128 VDD33 NET_3504 NET_5981 NET_1370 P33 l=0.300u w=30.000u
M129 NET_5981 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M130 PAD NET_79 NET_5987 NET_1370 P33 l=0.300u w=30.000u
M131 VDD33 NET_3504 NET_5987 NET_1370 P33 l=0.300u w=30.000u
M132 VDD33 NET_3504 NET_5986 NET_1370 P33 l=0.300u w=30.000u
M133 NET_5986 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M134 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M135 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M136 NET_95 NET_113 VDD VDD P33 l=0.300u w=5.000u
M137 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M138 PAD NET_79 NET_5979 NET_1370 P33 l=0.300u w=30.000u
M139 PAD NET_79 NET_5984 NET_1370 P33 l=0.300u w=30.000u
M140 NET_103 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 NET_103 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_106 NET_107 VDD33 P33 l=0.300u w=5.000u
M143 VDD33 NET_107 NET_106 VDD33 P33 l=0.300u w=5.000u
M144 NET_5973 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M145 NET_5973 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M146 PAD NET_79 NET_5971 NET_1370 P33 l=0.300u w=30.000u
M147 NET_5977 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M148 NET_5977 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M149 PAD NET_79 NET_5968 NET_1370 P33 l=0.300u w=30.000u
M150 NET_5979 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M151 NET_5984 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M152 VDD33 NET_10 NET_103 VDD33 P33 l=0.300u w=5.000u
M153 NET_103 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_64 NET_5969 NET_1370 P33 l=0.300u w=30.000u
M155 NET_5969 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M156 VDD33 NET_64 NET_5974 NET_1370 P33 l=0.300u w=30.000u
M157 NET_5974 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M158 VDD33 VSS NET_3504 VDD33 P33 l=0.300u w=5.000u
M159 VDD33 NET_10 NET_102 VDD33 P33 l=0.300u w=5.000u
M160 NET_5963 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M161 NET_5963 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M162 NET_5967 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M163 NET_5967 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M164 NET_10 NET_102 VDD33 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_64 NET_5961 NET_1370 P33 l=0.300u w=30.000u
M168 NET_5961 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M169 PAD NET_79 NET_5959 NET_1370 P33 l=0.300u w=30.000u
M170 VDD33 NET_64 NET_5965 NET_1370 P33 l=0.300u w=30.000u
M171 NET_5965 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M172 PAD NET_79 NET_5964 NET_1370 P33 l=0.300u w=30.000u
M173 NET_5949 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M174 NET_5957 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M175 NET_5959 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M176 NET_5964 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M177 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M178 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M181 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M182 PAD NET_79 NET_5947 NET_1370 P33 l=0.300u w=30.000u
M183 NET_5947 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M184 PAD NET_79 NET_5955 NET_1370 P33 l=0.300u w=30.000u
M185 NET_5955 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M186 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M187 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M188 VDD33 PAD NET_1370 NET_1370 P33 l=0.350u w=5.000u
M189 VDD33 NET_40 NET_3534 VDD33 P33 l=0.300u w=5.000u
M190 NET_5971 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M191 NET_5968 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M192 NET_5949 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M193 NET_5957 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M194 PAD VDD33 NET_1370 NET_1370 P33 l=0.350u w=15.000u
M195 PAD VDD33 NET_79 NET_1370 P33 l=0.350u w=10.000u
R1 PAD NET_40 300.135
.ends PBCU16

.subckt PBCU12   PAD OEN I C REN FP
M1 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M2 VSS NET_95 NET_85 VSS N18 l=0.180u w=2.000u
M3 VSS NET_95 NET_85 VSS N18 l=0.180u w=2.000u
M4 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M5 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M6 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M8 C NET_85 VSS VSS N18 l=0.180u w=2.000u
M9 VSS NET_85 C VSS N18 l=0.180u w=2.000u
M10 VSS OEN NET_46 VSS N18 l=0.180u w=2.000u
M11 VSS OEN NET_46 VSS N18 l=0.180u w=2.000u
M12 NET_46 I VSS VSS N18 l=0.180u w=2.000u
M13 VSS I NET_46 VSS N18 l=0.180u w=2.000u
M14 VSS REN NET_82 VSS N18 l=0.180u w=2.000u
M15 VSS NET_55 NET_51 VSS N18 l=0.180u w=4.000u
M16 VSS NET_55 NET_51 VSS N18 l=0.180u w=4.000u
M17 NET_56 I VSS VSS N18 l=0.180u w=4.000u
M18 NET_56 NET_57 NET_55 VSS N18 l=0.180u w=4.000u
M19 VSS OEN NET_57 VSS N18 l=0.180u w=2.000u
M20 VSS OEN NET_57 VSS N18 l=0.180u w=2.000u
M21 NET_60 NET_46 VSS VSS N18 l=0.180u w=2.000u
M22 VSS NET_46 NET_60 VSS N18 l=0.180u w=2.000u
M23 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_95 NET_85 VDD P18 l=0.180u w=5.000u
M25 VDD NET_95 NET_85 VDD P18 l=0.180u w=5.000u
M26 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M27 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_82 VDD P18 l=0.180u w=5.000u
M29 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M30 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M31 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M32 C NET_85 VDD VDD P18 l=0.180u w=5.000u
M33 VDD NET_85 C VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_57 VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_57 VDD P18 l=0.180u w=5.000u
M36 NET_6019 OEN NET_46 VDD P18 l=0.180u w=5.000u
M37 NET_6019 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M39 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M40 VDD NET_55 NET_51 VDD P18 l=0.180u w=5.000u
M41 VDD NET_55 NET_51 VDD P18 l=0.180u w=5.000u
M42 NET_55 I VDD VDD P18 l=0.180u w=5.000u
M43 NET_55 I VDD VDD P18 l=0.180u w=5.000u
M44 VDD NET_57 NET_55 VDD P18 l=0.180u w=5.000u
M45 NET_55 NET_57 VDD VDD P18 l=0.180u w=5.000u
M46 VDD NET_46 NET_60 VDD P18 l=0.180u w=5.000u
M47 NET_42 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_32 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_103 NET_30 VSSD N33 l=0.400u w=28.000u
M52 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M54 NET_28 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_44 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_39 NET_103 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_103 NET_37 VSSD N33 l=0.400u w=28.000u
M60 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M62 NET_35 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M63 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M64 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_17 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 VSSD NET_24 NET_15 VSSD N33 l=0.400u w=28.000u
M67 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M68 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M69 NET_13 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M70 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_23 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_24 NET_21 VSSD N33 l=0.400u w=28.000u
M74 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M75 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M76 NET_19 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M77 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M78 VSSD NET_24 NET_26 VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_33 VSSD N33 l=0.400u w=28.000u
M80 NET_102 NET_60 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_10 NET_103 VSS N33 l=0.350u w=8.000u
M82 VSS NET_10 NET_103 VSS N33 l=0.350u w=8.000u
M83 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M84 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M85 VSS NET_55 NET_67 VSS N33 l=0.350u w=5.330u
M86 VSS NET_55 NET_67 VSS N33 l=0.350u w=5.330u
M87 NET_67 NET_55 VSS VSS N33 l=0.350u w=5.330u
M88 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M89 NET_68 NET_51 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_51 NET_68 VSS N33 l=0.350u w=5.330u
M91 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M92 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M93 VSS NET_57 NET_76 VSS N33 l=0.350u w=7.440u
M94 NET_76 NET_57 VSS VSS N33 l=0.350u w=7.440u
M95 NET_81 NET_3504 NET_79 VSS N33 l=0.350u w=8.000u
M96 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M97 NET_102 NET_60 VSS VSS N33 l=0.350u w=8.000u
M98 VSS NET_46 NET_10 VSS N33 l=0.350u w=8.000u
M99 VSS NET_46 NET_10 VSS N33 l=0.350u w=8.000u
M100 VSS REN NET_106 VSS N33 l=0.350u w=8.000u
M101 VSS NET_82 NET_107 VSS N33 l=0.350u w=8.000u
M102 NET_40 VDD33 NET_109 VSS N33 l=0.350u w=8.000u
M103 NET_40 VDD33 NET_109 VSS N33 l=0.350u w=8.000u
M104 NET_109 VDD33 NET_40 VSS N33 l=0.350u w=8.000u
M105 VSS NET_109 NET_113 VSS N33 l=0.350u w=8.000u
M106 VDD NET_106 NET_117 VSS N33 l=0.350u w=4.000u
M107 VSS NET_113 NET_95 VSS N33 l=0.350u w=2.000u
M108 VSS NET_113 NET_95 VSS N33 l=0.350u w=2.000u
M109 VDD33 NET_106 NET_117 VDD33 P33 l=0.300u w=5.000u
M110 NET_5989 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M111 NET_5989 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M112 NET_5993 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M113 NET_5993 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M114 VDD33 NET_117 NET_40 NET_1370 P33 l=1.070u w=5.000u
M115 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M116 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M117 NET_95 NET_113 VDD VDD P33 l=0.300u w=5.000u
M118 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M119 NET_113 NET_109 NET_3534 VDD33 P33 l=0.300u w=5.000u
M120 NET_113 NET_109 NET_3534 VDD33 P33 l=0.300u w=5.000u
M121 NET_3534 NET_109 NET_113 VDD33 P33 l=0.300u w=5.000u
M122 NET_113 NET_109 NET_3534 VDD33 P33 l=0.300u w=5.000u
M123 NET_3534 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_40 NET_3534 VDD33 P33 l=0.300u w=5.000u
M125 NET_3534 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 PAD NET_79 NET_5983 NET_1370 P33 l=0.300u w=30.000u
M127 VDD33 NET_3504 NET_5983 NET_1370 P33 l=0.300u w=30.000u
M128 VDD33 NET_3504 NET_5981 NET_1370 P33 l=0.300u w=30.000u
M129 NET_5981 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M130 PAD NET_79 NET_5987 NET_1370 P33 l=0.300u w=30.000u
M131 VDD33 NET_3504 NET_5987 NET_1370 P33 l=0.300u w=30.000u
M132 VDD33 NET_3504 NET_5986 NET_1370 P33 l=0.300u w=30.000u
M133 NET_5986 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M134 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M135 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M136 NET_95 NET_113 VDD VDD P33 l=0.300u w=5.000u
M137 VDD NET_113 NET_95 VDD P33 l=0.300u w=5.000u
M138 PAD NET_79 NET_5979 NET_1370 P33 l=0.300u w=30.000u
M139 PAD NET_79 NET_5984 NET_1370 P33 l=0.300u w=30.000u
M140 NET_103 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 NET_103 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_106 NET_107 VDD33 P33 l=0.300u w=5.000u
M143 VDD33 NET_107 NET_106 VDD33 P33 l=0.300u w=5.000u
M144 NET_5973 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M145 NET_5973 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M146 PAD NET_79 NET_5971 NET_1370 P33 l=0.300u w=30.000u
M147 NET_5977 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M148 NET_5977 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M149 PAD NET_79 NET_5968 NET_1370 P33 l=0.300u w=30.000u
M150 NET_5979 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M151 NET_5984 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M152 VDD33 NET_10 NET_103 VDD33 P33 l=0.300u w=5.000u
M153 NET_103 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_64 NET_5969 NET_1370 P33 l=0.300u w=30.000u
M155 NET_5969 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M156 VDD33 NET_64 NET_5974 NET_1370 P33 l=0.300u w=30.000u
M157 NET_5974 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M158 VDD33 VSS NET_3504 VDD33 P33 l=0.300u w=5.000u
M159 VDD33 NET_10 NET_102 VDD33 P33 l=0.300u w=5.000u
M160 NET_5963 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M161 NET_5963 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M162 NET_5967 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M163 NET_5967 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M164 NET_10 NET_102 VDD33 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_64 NET_5961 NET_1370 P33 l=0.300u w=30.000u
M168 NET_5961 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M169 PAD NET_79 NET_5959 NET_1370 P33 l=0.300u w=30.000u
M170 VDD33 NET_64 NET_5965 NET_1370 P33 l=0.300u w=30.000u
M171 NET_5965 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M172 PAD NET_79 NET_5964 NET_1370 P33 l=0.300u w=30.000u
M173 NET_5949 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M174 NET_5957 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M175 NET_5959 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M176 NET_5964 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M177 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M178 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M181 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M182 PAD NET_79 NET_5947 NET_1370 P33 l=0.300u w=30.000u
M183 NET_5947 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M184 PAD NET_79 NET_5955 NET_1370 P33 l=0.300u w=30.000u
M185 NET_5955 NET_64 VDD33 NET_1370 P33 l=0.300u w=30.000u
M186 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M187 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M188 VDD33 PAD NET_1370 NET_1370 P33 l=0.350u w=5.000u
M189 VDD33 NET_40 NET_3534 VDD33 P33 l=0.300u w=5.000u
M190 NET_5971 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M191 NET_5968 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M192 NET_5949 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M193 NET_5957 NET_79 PAD NET_1370 P33 l=0.300u w=30.000u
M194 PAD VDD33 NET_1370 NET_1370 P33 l=0.350u w=15.000u
M195 PAD VDD33 NET_79 NET_1370 P33 l=0.350u w=10.000u
R1 PAD NET_40 300.135
.ends PBCU12

.subckt PBCDL8   PAD OEN I C REN FP
M1 VSS REN NET_99 VSS N18 l=0.180u w=2.000u
M2 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M4 C NET_109 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M6 C NET_109 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_112 NET_109 VSS N18 l=0.180u w=2.000u
M9 VSS NET_112 NET_109 VSS N18 l=0.180u w=2.000u
M10 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M11 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M12 NET_69 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_69 NET_70 NET_68 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M18 NET_73 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_73 VSS N18 l=0.180u w=2.000u
M20 VSS NET_73 NET_10 VSS N18 l=0.180u w=2.000u
M21 VSS NET_73 NET_10 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_99 VSS N18 l=0.180u w=2.000u
M23 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_112 NET_109 VDD P18 l=0.180u w=5.000u
M25 VDD NET_112 NET_109 VDD P18 l=0.180u w=5.000u
M26 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M27 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_99 VDD P18 l=0.180u w=5.000u
M29 VDD REN NET_99 VDD P18 l=0.180u w=5.000u
M30 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M31 C NET_109 VDD VDD P18 l=0.180u w=5.000u
M32 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M33 C NET_109 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M36 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M37 NET_6035 OEN NET_73 VDD P18 l=0.180u w=5.000u
M38 NET_6035 I VDD VDD P18 l=0.180u w=5.000u
M39 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M40 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M41 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M42 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M43 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_70 NET_68 VDD P18 l=0.180u w=5.000u
M46 NET_68 NET_70 VDD VDD P18 l=0.180u w=5.000u
M47 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_31 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_11 NET_29 VSSD N33 l=0.400u w=28.000u
M51 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M52 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M53 NET_27 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M55 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M56 NET_38 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_11 NET_36 VSSD N33 l=0.400u w=28.000u
M58 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M60 NET_34 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_17 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_11 NET_15 VSSD N33 l=0.400u w=28.000u
M65 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M67 NET_13 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_11 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD VDD33 NET_11 VSSD N33 l=0.350u w=4.000u
M76 NET_41 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_11 NET_25 VSSD N33 l=0.400u w=28.000u
M78 NET_43 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_11 NET_32 VSSD N33 l=0.400u w=28.000u
M80 NET_84 NET_10 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_45 NET_85 VSS N33 l=0.350u w=8.000u
M82 VSS NET_45 NET_85 VSS N33 l=0.350u w=8.000u
M83 NET_47 NET_48 VSS VSS N33 l=0.350u w=4.600u
M84 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M85 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M86 NET_48 NET_68 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M88 NET_49 NET_64 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M90 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M91 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M92 VSS NET_70 NET_57 VSS N33 l=0.350u w=7.440u
M93 NET_57 NET_70 VSS VSS N33 l=0.350u w=7.440u
M94 NET_62 NET_3499 NET_60 VSS N33 l=0.350u w=8.000u
M95 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M96 NET_84 NET_10 VSS VSS N33 l=0.350u w=8.000u
M97 VSS NET_73 NET_45 VSS N33 l=0.350u w=8.000u
M98 VSS NET_73 NET_45 VSS N33 l=0.350u w=8.000u
M99 VSS REN NET_88 VSS N33 l=0.350u w=8.000u
M100 VSS NET_99 NET_89 VSS N33 l=0.350u w=8.000u
M101 NET_44 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M102 NET_44 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M103 NET_91 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M104 VSS NET_91 NET_95 VSS N33 l=0.350u w=8.000u
M105 NET_91 NET_88 VSS VSS N33 l=4.550u w=0.800u
M106 VSS NET_95 NET_112 VSS N33 l=0.350u w=2.000u
M107 VSS NET_95 NET_112 VSS N33 l=0.350u w=2.000u
M108 NET_6004 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M109 NET_6004 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M110 NET_6008 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M111 NET_6008 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M112 NET_1369 NET_1369 NET_1369 NET_1369 P33 l=1.070u w=5.000u
M113 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M114 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M115 NET_112 NET_95 VDD VDD P33 l=0.300u w=5.000u
M116 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M117 NET_95 NET_91 NET_3536 VDD33 P33 l=0.300u w=5.000u
M118 NET_95 NET_91 NET_3536 VDD33 P33 l=0.300u w=5.000u
M119 NET_95 NET_91 NET_3536 VDD33 P33 l=0.300u w=5.000u
M120 NET_95 NET_91 NET_3536 VDD33 P33 l=0.300u w=5.000u
M121 NET_3536 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M122 VDD33 NET_44 NET_3536 VDD33 P33 l=0.300u w=5.000u
M123 NET_3536 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 PAD NET_60 NET_5992 NET_1369 P33 l=0.300u w=30.000u
M125 VDD33 NET_3499 NET_5992 NET_1369 P33 l=0.300u w=30.000u
M126 VDD33 NET_3499 NET_5990 NET_1369 P33 l=0.300u w=30.000u
M127 NET_5990 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M128 PAD NET_60 NET_6002 NET_1369 P33 l=0.300u w=30.000u
M129 VDD33 NET_3499 NET_6002 NET_1369 P33 l=0.300u w=30.000u
M130 VDD33 NET_3499 NET_6001 NET_1369 P33 l=0.300u w=30.000u
M131 NET_6001 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M132 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M133 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M134 NET_112 NET_95 VDD VDD P33 l=0.300u w=5.000u
M135 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M136 PAD NET_60 NET_5988 NET_1369 P33 l=0.300u w=30.000u
M137 PAD NET_60 NET_5999 NET_1369 P33 l=0.300u w=30.000u
M138 VDD33 NET_88 NET_89 VDD33 P33 l=0.300u w=5.000u
M139 VDD33 NET_89 NET_88 VDD33 P33 l=0.300u w=5.000u
M140 NET_85 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 NET_5987 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M142 NET_5987 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M143 PAD NET_60 NET_5985 NET_1369 P33 l=0.300u w=30.000u
M144 NET_5998 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M145 NET_5998 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M146 PAD NET_60 NET_5981 NET_1369 P33 l=0.300u w=30.000u
M147 NET_5988 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M148 NET_5999 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M149 VDD33 NET_3499 NET_5983 NET_1369 P33 l=0.300u w=30.000u
M150 NET_5983 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M151 VDD33 NET_3499 NET_5993 NET_1369 P33 l=0.300u w=30.000u
M152 NET_5993 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M153 VDD33 VSS NET_3499 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_45 NET_84 VDD33 P33 l=0.300u w=5.000u
M155 NET_5964 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M156 NET_5964 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M157 NET_5978 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M158 NET_5978 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M159 NET_45 NET_84 VDD33 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_47 NET_5962 NET_1369 P33 l=0.300u w=30.000u
M163 NET_5962 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M164 PAD NET_60 NET_5960 NET_1369 P33 l=0.300u w=30.000u
M165 VDD33 NET_47 NET_5976 NET_1369 P33 l=0.300u w=30.000u
M166 NET_5976 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M167 PAD NET_60 NET_5975 NET_1369 P33 l=0.300u w=30.000u
M168 NET_5959 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M169 NET_5974 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M170 NET_5960 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M171 NET_5975 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M172 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M174 NET_47 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M178 PAD NET_60 NET_5957 NET_1369 P33 l=0.300u w=30.000u
M179 NET_5957 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M180 PAD NET_60 NET_5972 NET_1369 P33 l=0.300u w=30.000u
M181 NET_5972 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M182 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M183 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M184 VDD33 PAD NET_1369 NET_1369 P33 l=0.350u w=5.000u
M185 VDD33 NET_44 NET_3536 VDD33 P33 l=0.300u w=5.000u
M186 NET_5985 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M187 NET_5981 NET_3499 VDD33 NET_1369 P33 l=0.300u w=30.000u
M188 NET_5959 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M189 NET_5974 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M190 PAD VDD33 NET_1369 NET_1369 P33 l=0.350u w=15.000u
M191 PAD VDD33 NET_60 NET_1369 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBCDL8

.subckt PBCDL24   PAD OEN I C REN FP
M1 VSS REN NET_99 VSS N18 l=0.180u w=2.000u
M2 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M4 C NET_109 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M6 C NET_109 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_112 NET_109 VSS N18 l=0.180u w=2.000u
M9 VSS NET_112 NET_109 VSS N18 l=0.180u w=2.000u
M10 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M11 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M12 NET_69 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_69 NET_70 NET_68 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M18 NET_73 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_73 VSS N18 l=0.180u w=2.000u
M20 VSS NET_73 NET_10 VSS N18 l=0.180u w=2.000u
M21 VSS NET_73 NET_10 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_99 VSS N18 l=0.180u w=2.000u
M23 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_112 NET_109 VDD P18 l=0.180u w=5.000u
M25 VDD NET_112 NET_109 VDD P18 l=0.180u w=5.000u
M26 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M27 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_99 VDD P18 l=0.180u w=5.000u
M29 VDD REN NET_99 VDD P18 l=0.180u w=5.000u
M30 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M31 C NET_109 VDD VDD P18 l=0.180u w=5.000u
M32 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M33 C NET_109 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M36 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M37 NET_6033 OEN NET_73 VDD P18 l=0.180u w=5.000u
M38 NET_6033 I VDD VDD P18 l=0.180u w=5.000u
M39 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M40 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M41 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M42 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M43 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_70 NET_68 VDD P18 l=0.180u w=5.000u
M46 NET_68 NET_70 VDD VDD P18 l=0.180u w=5.000u
M47 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_31 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_85 NET_29 VSSD N33 l=0.400u w=28.000u
M51 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M52 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M53 NET_27 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M55 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M56 NET_38 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_85 NET_36 VSSD N33 l=0.400u w=28.000u
M58 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M60 NET_34 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_17 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_11 NET_15 VSSD N33 l=0.400u w=28.000u
M65 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M67 NET_13 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_85 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD VDD33 NET_11 VSSD N33 l=0.350u w=4.000u
M76 NET_41 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_11 NET_25 VSSD N33 l=0.400u w=28.000u
M78 NET_43 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_85 NET_32 VSSD N33 l=0.400u w=28.000u
M80 NET_84 NET_10 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_45 NET_85 VSS N33 l=0.350u w=8.000u
M82 VSS NET_45 NET_85 VSS N33 l=0.350u w=8.000u
M83 NET_47 NET_48 VSS VSS N33 l=0.350u w=4.400u
M84 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M85 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M86 NET_48 NET_68 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M88 NET_49 NET_64 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M90 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M91 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M92 VSS NET_70 NET_57 VSS N33 l=0.350u w=7.440u
M93 NET_57 NET_70 VSS VSS N33 l=0.350u w=7.440u
M94 NET_62 NET_3499 NET_60 VSS N33 l=0.350u w=8.000u
M95 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M96 NET_84 NET_10 VSS VSS N33 l=0.350u w=8.000u
M97 VSS NET_73 NET_45 VSS N33 l=0.350u w=8.000u
M98 VSS NET_73 NET_45 VSS N33 l=0.350u w=8.000u
M99 VSS REN NET_88 VSS N33 l=0.350u w=8.000u
M100 VSS NET_99 NET_89 VSS N33 l=0.350u w=8.000u
M101 NET_44 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M102 NET_44 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M103 NET_91 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M104 VSS NET_91 NET_95 VSS N33 l=0.350u w=8.000u
M105 NET_91 NET_88 VSS VSS N33 l=4.550u w=0.800u
M106 VSS NET_95 NET_112 VSS N33 l=0.350u w=2.000u
M107 VSS NET_95 NET_112 VSS N33 l=0.350u w=2.000u
M108 NET_6002 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M109 NET_6002 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M110 NET_6006 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M111 NET_6006 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M112 NET_1369 NET_1369 NET_1369 NET_1369 P33 l=1.070u w=5.000u
M113 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M114 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M115 NET_112 NET_95 VDD VDD P33 l=0.300u w=5.000u
M116 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M117 PAD NET_60 NET_5990 NET_1369 P33 l=0.300u w=30.000u
M118 VDD33 NET_47 NET_5990 NET_1369 P33 l=0.300u w=30.000u
M119 VDD33 NET_47 NET_5988 NET_1369 P33 l=0.300u w=30.000u
M120 NET_5988 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M121 PAD NET_60 NET_6000 NET_1369 P33 l=0.300u w=30.000u
M122 VDD33 NET_47 NET_6000 NET_1369 P33 l=0.300u w=30.000u
M123 VDD33 NET_47 NET_5999 NET_1369 P33 l=0.300u w=30.000u
M124 NET_5999 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M125 NET_95 NET_91 NET_3534 VDD33 P33 l=0.300u w=5.000u
M126 NET_95 NET_91 NET_3534 VDD33 P33 l=0.300u w=5.000u
M127 NET_95 NET_91 NET_3534 VDD33 P33 l=0.300u w=5.000u
M128 NET_95 NET_91 NET_3534 VDD33 P33 l=0.300u w=5.000u
M129 NET_3534 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M130 VDD33 NET_44 NET_3534 VDD33 P33 l=0.300u w=5.000u
M131 NET_3534 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M132 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M133 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M134 NET_112 NET_95 VDD VDD P33 l=0.300u w=5.000u
M135 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M136 PAD NET_60 NET_5986 NET_1369 P33 l=0.300u w=30.000u
M137 PAD NET_60 NET_5997 NET_1369 P33 l=0.300u w=30.000u
M138 NET_5985 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M139 NET_5985 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M140 PAD NET_60 NET_5983 NET_1369 P33 l=0.300u w=30.000u
M141 NET_5996 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M142 NET_5996 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M143 PAD NET_60 NET_5979 NET_1369 P33 l=0.300u w=30.000u
M144 VDD33 NET_88 NET_89 VDD33 P33 l=0.300u w=5.000u
M145 VDD33 NET_89 NET_88 VDD33 P33 l=0.300u w=5.000u
M146 VDD33 NET_45 NET_85 VDD33 P33 l=0.300u w=4.600u
M147 NET_5986 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M148 NET_5997 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M149 VDD33 NET_47 NET_5981 NET_1369 P33 l=0.300u w=30.000u
M150 NET_5981 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M151 VDD33 NET_47 NET_5991 NET_1369 P33 l=0.300u w=30.000u
M152 NET_5991 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M153 NET_5962 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M154 NET_5962 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M155 NET_5976 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M156 NET_5976 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M157 VDD33 VSS NET_3499 VDD33 P33 l=0.300u w=5.000u
M158 VDD33 NET_45 NET_84 VDD33 P33 l=0.300u w=5.000u
M159 NET_45 NET_84 VDD33 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_47 NET_5960 NET_1369 P33 l=0.300u w=30.000u
M161 NET_5960 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M162 PAD NET_60 NET_5958 NET_1369 P33 l=0.300u w=30.000u
M163 VDD33 NET_47 NET_5974 NET_1369 P33 l=0.300u w=30.000u
M164 NET_5974 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M165 PAD NET_60 NET_5973 NET_1369 P33 l=0.300u w=30.000u
M166 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M167 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M168 NET_5957 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M169 NET_5972 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M170 NET_5958 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M171 NET_5973 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M172 PAD NET_60 NET_5955 NET_1369 P33 l=0.300u w=30.000u
M173 NET_5955 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M174 PAD NET_60 NET_5970 NET_1369 P33 l=0.300u w=30.000u
M175 NET_5970 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M176 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M177 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M178 VDD33 PAD NET_1369 NET_1369 P33 l=0.350u w=5.000u
M179 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M181 NET_47 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M182 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M183 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M184 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M185 VDD33 NET_44 NET_3534 VDD33 P33 l=0.300u w=5.000u
M186 NET_5983 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M187 NET_5979 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M188 NET_5957 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M189 NET_5972 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M190 PAD VDD33 NET_1369 NET_1369 P33 l=0.350u w=15.000u
M191 PAD VDD33 NET_60 NET_1369 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBCDL24

.subckt PBCDL16   PAD OEN I C REN FP
M1 VSS REN NET_99 VSS N18 l=0.180u w=2.000u
M2 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M4 C NET_109 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M6 C NET_109 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_109 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_112 NET_109 VSS N18 l=0.180u w=2.000u
M9 VSS NET_112 NET_109 VSS N18 l=0.180u w=2.000u
M10 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M11 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M12 NET_69 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_69 NET_70 NET_68 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M18 NET_73 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_73 VSS N18 l=0.180u w=2.000u
M20 VSS NET_73 NET_10 VSS N18 l=0.180u w=2.000u
M21 VSS NET_73 NET_10 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_99 VSS N18 l=0.180u w=2.000u
M23 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_112 NET_109 VDD P18 l=0.180u w=5.000u
M25 VDD NET_112 NET_109 VDD P18 l=0.180u w=5.000u
M26 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M27 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_99 VDD P18 l=0.180u w=5.000u
M29 VDD REN NET_99 VDD P18 l=0.180u w=5.000u
M30 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M31 C NET_109 VDD VDD P18 l=0.180u w=5.000u
M32 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M33 C NET_109 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_109 C VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M36 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M37 NET_6025 OEN NET_73 VDD P18 l=0.180u w=5.000u
M38 NET_6025 I VDD VDD P18 l=0.180u w=5.000u
M39 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M40 VDD NET_73 NET_10 VDD P18 l=0.180u w=5.000u
M41 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M42 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M43 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_70 NET_68 VDD P18 l=0.180u w=5.000u
M46 NET_68 NET_70 VDD VDD P18 l=0.180u w=5.000u
M47 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_31 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_85 NET_29 VSSD N33 l=0.400u w=28.000u
M51 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M52 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M53 NET_27 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M55 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M56 NET_38 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_85 NET_36 VSSD N33 l=0.400u w=28.000u
M58 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M60 NET_34 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M65 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M67 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_41 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M78 NET_43 NET_85 VSSD VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M80 NET_84 NET_10 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_45 NET_85 VSS N33 l=0.350u w=8.000u
M82 VSS NET_45 NET_85 VSS N33 l=0.350u w=8.000u
M83 NET_47 NET_48 VSS VSS N33 l=0.350u w=3.400u
M84 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M85 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M86 NET_48 NET_68 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M88 NET_49 NET_64 VSS VSS N33 l=0.350u w=5.330u
M89 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M90 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M91 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M92 VSS NET_70 NET_57 VSS N33 l=0.350u w=7.440u
M93 NET_57 NET_70 VSS VSS N33 l=0.350u w=7.440u
M94 NET_62 NET_3506 NET_60 VSS N33 l=0.350u w=8.000u
M95 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M96 NET_84 NET_10 VSS VSS N33 l=0.350u w=8.000u
M97 VSS NET_73 NET_45 VSS N33 l=0.350u w=8.000u
M98 VSS NET_73 NET_45 VSS N33 l=0.350u w=8.000u
M99 VSS REN NET_88 VSS N33 l=0.350u w=8.000u
M100 VSS NET_99 NET_89 VSS N33 l=0.350u w=8.000u
M101 NET_44 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M102 NET_44 VDD33 NET_91 VSS N33 l=0.350u w=8.000u
M103 NET_91 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M104 VSS NET_91 NET_95 VSS N33 l=0.350u w=8.000u
M105 NET_91 NET_88 VSS VSS N33 l=4.550u w=0.800u
M106 VSS NET_95 NET_112 VSS N33 l=0.350u w=2.000u
M107 VSS NET_95 NET_112 VSS N33 l=0.350u w=2.000u
M108 NET_5994 NET_3506 VDD33 NET_1369 P33 l=0.300u w=30.000u
M109 NET_5994 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M110 NET_5998 NET_3506 VDD33 NET_1369 P33 l=0.300u w=30.000u
M111 NET_5998 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M112 NET_1369 NET_1369 NET_1369 NET_1369 P33 l=1.070u w=5.000u
M113 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M114 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M115 NET_112 NET_95 VDD VDD P33 l=0.300u w=5.000u
M116 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M117 NET_95 NET_91 NET_3540 VDD33 P33 l=0.300u w=5.000u
M118 NET_95 NET_91 NET_3540 VDD33 P33 l=0.300u w=5.000u
M119 NET_95 NET_91 NET_3540 VDD33 P33 l=0.300u w=5.000u
M120 NET_95 NET_91 NET_3540 VDD33 P33 l=0.300u w=5.000u
M121 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M122 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M123 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 PAD NET_60 NET_5982 NET_1369 P33 l=0.300u w=30.000u
M125 VDD33 NET_3506 NET_5982 NET_1369 P33 l=0.300u w=30.000u
M126 VDD33 NET_3506 NET_5980 NET_1369 P33 l=0.300u w=30.000u
M127 NET_5980 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M128 PAD NET_60 NET_5992 NET_1369 P33 l=0.300u w=30.000u
M129 VDD33 NET_3506 NET_5992 NET_1369 P33 l=0.300u w=30.000u
M130 VDD33 NET_3506 NET_5991 NET_1369 P33 l=0.300u w=30.000u
M131 NET_5991 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M132 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M133 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M134 NET_112 NET_95 VDD VDD P33 l=0.300u w=5.000u
M135 VDD NET_95 NET_112 VDD P33 l=0.300u w=5.000u
M136 PAD NET_60 NET_5978 NET_1369 P33 l=0.300u w=30.000u
M137 PAD NET_60 NET_5989 NET_1369 P33 l=0.300u w=30.000u
M138 VDD33 NET_88 NET_89 VDD33 P33 l=0.300u w=5.000u
M139 VDD33 NET_89 NET_88 VDD33 P33 l=0.300u w=5.000u
M140 NET_85 NET_45 VDD33 VDD33 P33 l=0.300u w=3.600u
M141 NET_5977 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M142 NET_5977 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M143 PAD NET_60 NET_5975 NET_1369 P33 l=0.300u w=30.000u
M144 NET_5988 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M145 NET_5988 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M146 PAD NET_60 NET_5971 NET_1369 P33 l=0.300u w=30.000u
M147 NET_5978 NET_3506 VDD33 NET_1369 P33 l=0.300u w=30.000u
M148 NET_5989 NET_3506 VDD33 NET_1369 P33 l=0.300u w=30.000u
M149 VDD33 NET_47 NET_5973 NET_1369 P33 l=0.300u w=30.000u
M150 NET_5973 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M151 VDD33 NET_47 NET_5983 NET_1369 P33 l=0.300u w=30.000u
M152 NET_5983 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M153 VDD33 VSS NET_3506 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_45 NET_84 VDD33 P33 l=0.300u w=5.000u
M155 NET_5954 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M156 NET_5954 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M157 NET_5968 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M158 NET_5968 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M159 NET_45 NET_84 VDD33 VDD33 P33 l=0.300u w=5.000u
M160 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_47 NET_5952 NET_1369 P33 l=0.300u w=30.000u
M163 NET_5952 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M164 PAD NET_60 NET_5950 NET_1369 P33 l=0.300u w=30.000u
M165 VDD33 NET_47 NET_5966 NET_1369 P33 l=0.300u w=30.000u
M166 NET_5966 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M167 PAD NET_60 NET_5965 NET_1369 P33 l=0.300u w=30.000u
M168 NET_5949 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M169 NET_5964 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M170 NET_5950 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M171 NET_5965 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M172 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M173 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M174 NET_47 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_48 NET_47 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M178 PAD NET_60 NET_5947 NET_1369 P33 l=0.300u w=30.000u
M179 NET_5947 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M180 PAD NET_60 NET_5962 NET_1369 P33 l=0.300u w=30.000u
M181 NET_5962 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M182 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M183 NET_1369 PAD VDD33 NET_1369 P33 l=0.350u w=5.000u
M184 VDD33 PAD NET_1369 NET_1369 P33 l=0.350u w=5.000u
M185 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M186 NET_5975 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M187 NET_5971 NET_47 VDD33 NET_1369 P33 l=0.300u w=30.000u
M188 NET_5949 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M189 NET_5964 NET_60 PAD NET_1369 P33 l=0.300u w=30.000u
M190 PAD VDD33 NET_1369 NET_1369 P33 l=0.350u w=15.000u
M191 PAD VDD33 NET_60 NET_1369 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBCDL16

.subckt PBCDL12   PAD OEN I C REN FP
M1 VSS REN NET_100 VSS N18 l=0.180u w=2.000u
M2 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M4 C NET_110 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M6 C NET_110 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_113 NET_110 VSS N18 l=0.180u w=2.000u
M9 VSS NET_113 NET_110 VSS N18 l=0.180u w=2.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M12 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M18 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M21 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_100 VSS N18 l=0.180u w=2.000u
M23 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_113 NET_110 VDD P18 l=0.180u w=5.000u
M25 VDD NET_113 NET_110 VDD P18 l=0.180u w=5.000u
M26 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M27 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_100 VDD P18 l=0.180u w=5.000u
M29 VDD REN NET_100 VDD P18 l=0.180u w=5.000u
M30 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M31 C NET_110 VDD VDD P18 l=0.180u w=5.000u
M32 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M33 C NET_110 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M36 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M37 NET_6058 OEN NET_74 VDD P18 l=0.180u w=5.000u
M38 NET_6058 I VDD VDD P18 l=0.180u w=5.000u
M39 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M40 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M41 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M42 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M43 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M46 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M47 NET_42 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_32 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_86 NET_30 VSSD N33 l=0.400u w=28.000u
M51 NET_30 FP PAD VSSD N33 l=0.400u w=28.000u
M52 PAD FP NET_28 VSSD N33 l=0.400u w=28.000u
M53 NET_28 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_44 FP PAD VSSD N33 l=0.400u w=28.000u
M55 NET_39 FP PAD VSSD N33 l=0.400u w=28.000u
M56 NET_39 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_86 NET_37 VSSD N33 l=0.400u w=28.000u
M58 NET_37 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_35 VSSD N33 l=0.400u w=28.000u
M60 NET_35 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_26 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_17 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_11 NET_15 VSSD N33 l=0.400u w=28.000u
M65 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M67 NET_13 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M68 NET_33 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_23 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_11 NET_21 VSSD N33 l=0.400u w=28.000u
M72 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M74 NET_19 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M75 VSSD VDD33 NET_11 VSSD N33 l=0.350u w=4.000u
M76 NET_42 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_11 NET_26 VSSD N33 l=0.400u w=28.000u
M78 NET_44 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_11 NET_33 VSSD N33 l=0.400u w=28.000u
M80 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_45 NET_86 VSS N33 l=0.350u w=8.000u
M82 VSS NET_45 NET_86 VSS N33 l=0.350u w=8.000u
M83 VSS NET_49 NET_46 VSS N33 l=0.350u w=5.000u
M84 VSS NET_49 NET_46 VSS N33 l=0.350u w=5.000u
M85 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M86 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M87 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M88 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M89 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M91 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M92 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M93 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M94 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M95 NET_63 NET_3507 NET_61 VSS N33 l=0.350u w=8.000u
M96 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M97 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M98 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M99 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M100 VSS REN NET_89 VSS N33 l=0.350u w=8.000u
M101 VSS NET_100 NET_90 VSS N33 l=0.350u w=8.000u
M102 NET_40 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M103 NET_40 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M104 NET_92 VDD33 NET_40 VSS N33 l=0.350u w=8.000u
M105 VSS NET_92 NET_96 VSS N33 l=0.350u w=8.000u
M106 NET_92 NET_89 VSS VSS N33 l=4.550u w=0.800u
M107 VSS NET_96 NET_113 VSS N33 l=0.350u w=2.000u
M108 VSS NET_96 NET_113 VSS N33 l=0.350u w=2.000u
M109 NET_6027 NET_3507 VDD33 NET_1370 P33 l=0.300u w=30.000u
M110 NET_6027 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M111 NET_6031 NET_3507 VDD33 NET_1370 P33 l=0.300u w=30.000u
M112 NET_6031 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M113 NET_1370 NET_1370 NET_1370 NET_1370 P33 l=1.070u w=5.000u
M114 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M115 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M116 NET_113 NET_96 VDD VDD P33 l=0.300u w=5.000u
M117 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M118 NET_96 NET_92 NET_3544 VDD33 P33 l=0.300u w=5.000u
M119 NET_96 NET_92 NET_3544 VDD33 P33 l=0.300u w=5.000u
M120 NET_96 NET_92 NET_3544 VDD33 P33 l=0.300u w=5.000u
M121 NET_96 NET_92 NET_3544 VDD33 P33 l=0.300u w=5.000u
M122 NET_3544 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_40 NET_3544 VDD33 P33 l=0.300u w=5.000u
M124 NET_3544 NET_40 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 PAD NET_61 NET_6015 NET_1370 P33 l=0.300u w=30.000u
M126 VDD33 NET_3507 NET_6015 NET_1370 P33 l=0.300u w=30.000u
M127 VDD33 NET_3507 NET_6013 NET_1370 P33 l=0.300u w=30.000u
M128 NET_6013 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M129 PAD NET_61 NET_6025 NET_1370 P33 l=0.300u w=30.000u
M130 VDD33 NET_3507 NET_6025 NET_1370 P33 l=0.300u w=30.000u
M131 VDD33 NET_3507 NET_6024 NET_1370 P33 l=0.300u w=30.000u
M132 NET_6024 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M133 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M134 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M135 NET_113 NET_96 VDD VDD P33 l=0.300u w=5.000u
M136 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M137 PAD NET_61 NET_6011 NET_1370 P33 l=0.300u w=30.000u
M138 PAD NET_61 NET_6022 NET_1370 P33 l=0.300u w=30.000u
M139 VDD33 NET_89 NET_90 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_90 NET_89 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_45 NET_86 VDD33 P33 l=0.300u w=4.800u
M142 VDD33 NET_45 NET_86 VDD33 P33 l=0.300u w=4.800u
M143 NET_6010 NET_3507 VDD33 NET_1370 P33 l=0.300u w=30.000u
M144 NET_6010 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M145 PAD NET_61 NET_6008 NET_1370 P33 l=0.300u w=30.000u
M146 NET_6021 NET_3507 VDD33 NET_1370 P33 l=0.300u w=30.000u
M147 NET_6021 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M148 PAD NET_61 NET_6004 NET_1370 P33 l=0.300u w=30.000u
M149 NET_6011 NET_3507 VDD33 NET_1370 P33 l=0.300u w=30.000u
M150 NET_6022 NET_3507 VDD33 NET_1370 P33 l=0.300u w=30.000u
M151 VDD33 NET_46 NET_6006 NET_1370 P33 l=0.300u w=30.000u
M152 NET_6006 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M153 VDD33 NET_46 NET_6016 NET_1370 P33 l=0.300u w=30.000u
M154 NET_6016 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M155 VDD33 VSS NET_3507 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_45 NET_85 VDD33 P33 l=0.300u w=5.000u
M157 NET_5987 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M158 NET_5987 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M159 NET_6001 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M160 NET_6001 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M161 NET_45 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_46 NET_5985 NET_1370 P33 l=0.300u w=30.000u
M165 NET_5985 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M166 PAD NET_61 NET_5983 NET_1370 P33 l=0.300u w=30.000u
M167 VDD33 NET_46 NET_5999 NET_1370 P33 l=0.300u w=30.000u
M168 NET_5999 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M169 PAD NET_61 NET_5998 NET_1370 P33 l=0.300u w=30.000u
M170 NET_5982 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M171 NET_5997 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M172 NET_5983 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M173 NET_5998 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M174 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M176 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M180 PAD NET_61 NET_5980 NET_1370 P33 l=0.300u w=30.000u
M181 NET_5980 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M182 PAD NET_61 NET_5995 NET_1370 P33 l=0.300u w=30.000u
M183 NET_5995 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M184 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M185 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M186 VDD33 PAD NET_1370 NET_1370 P33 l=0.350u w=5.000u
M187 VDD33 NET_40 NET_3544 VDD33 P33 l=0.300u w=5.000u
M188 NET_6008 NET_3507 VDD33 NET_1370 P33 l=0.300u w=30.000u
M189 NET_6004 NET_3507 VDD33 NET_1370 P33 l=0.300u w=30.000u
M190 NET_5982 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M191 NET_5997 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M192 PAD VDD33 NET_1370 NET_1370 P33 l=0.350u w=15.000u
M193 PAD VDD33 NET_61 NET_1370 P33 l=0.350u w=10.000u
R1 PAD NET_40 300.135
.ends PBCDL12

.subckt PBCD8   PAD OEN I C REN FP
M1 VSS REN NET_100 VSS N18 l=0.180u w=2.000u
M2 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M4 C NET_110 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M6 C NET_110 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_113 NET_110 VSS N18 l=0.180u w=2.000u
M9 VSS NET_113 NET_110 VSS N18 l=0.180u w=2.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M12 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M18 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M21 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_100 VSS N18 l=0.180u w=2.000u
M23 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_113 NET_110 VDD P18 l=0.180u w=5.000u
M25 VDD NET_113 NET_110 VDD P18 l=0.180u w=5.000u
M26 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M27 VDD REN NET_100 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_100 VDD P18 l=0.180u w=5.000u
M29 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M30 C NET_110 VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M32 C NET_110 VDD VDD P18 l=0.180u w=5.000u
M33 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M36 NET_6081 OEN NET_74 VDD P18 l=0.180u w=5.000u
M37 NET_6081 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M39 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M40 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M41 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M42 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M43 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M44 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M45 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M46 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M47 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_31 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M51 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M52 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M53 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M55 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M56 NET_38 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M58 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M60 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M65 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M67 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_41 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M78 NET_43 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M80 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_45 NET_86 VSS N33 l=0.350u w=8.000u
M82 VSS NET_45 NET_86 VSS N33 l=0.350u w=8.000u
M83 VSS NET_49 NET_46 VSS N33 l=0.350u w=10.000u
M84 VSS NET_49 NET_46 VSS N33 l=0.350u w=10.000u
M85 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M86 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M87 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M88 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M89 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M91 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M92 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M93 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M94 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M95 NET_63 NET_3504 NET_61 VSS N33 l=0.350u w=8.000u
M96 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M97 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M98 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M99 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M100 VSS REN NET_89 VSS N33 l=0.350u w=8.000u
M101 VSS NET_100 NET_90 VSS N33 l=0.350u w=8.000u
M102 NET_44 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M103 NET_44 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M104 NET_92 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M105 VSS NET_92 NET_96 VSS N33 l=0.350u w=8.000u
M106 NET_92 NET_89 VSS VSS N33 l=4.550u w=0.800u
M107 VSS NET_96 NET_113 VSS N33 l=0.350u w=2.000u
M108 VSS NET_96 NET_113 VSS N33 l=0.350u w=2.000u
M109 NET_6051 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M110 NET_6051 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M111 NET_6055 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M112 NET_6055 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M113 NET_1370 NET_1370 NET_1370 NET_1370 P33 l=1.070u w=5.000u
M114 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M115 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M116 NET_113 NET_96 VDD VDD P33 l=0.300u w=5.000u
M117 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M118 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M119 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M120 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M121 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M122 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M124 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 PAD NET_61 NET_6039 NET_1370 P33 l=0.300u w=30.000u
M126 VDD33 NET_3504 NET_6039 NET_1370 P33 l=0.300u w=30.000u
M127 VDD33 NET_3504 NET_6037 NET_1370 P33 l=0.300u w=30.000u
M128 NET_6037 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M129 PAD NET_61 NET_6049 NET_1370 P33 l=0.300u w=30.000u
M130 VDD33 NET_3504 NET_6049 NET_1370 P33 l=0.300u w=30.000u
M131 VDD33 NET_3504 NET_6048 NET_1370 P33 l=0.300u w=30.000u
M132 NET_6048 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M133 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M134 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M135 NET_113 NET_96 VDD VDD P33 l=0.300u w=5.000u
M136 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M137 PAD NET_61 NET_6035 NET_1370 P33 l=0.300u w=30.000u
M138 PAD NET_61 NET_6046 NET_1370 P33 l=0.300u w=30.000u
M139 NET_86 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M140 NET_86 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_89 NET_90 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_90 NET_89 VDD33 P33 l=0.300u w=5.000u
M143 NET_6034 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M144 NET_6034 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M145 PAD NET_61 NET_6032 NET_1370 P33 l=0.300u w=30.000u
M146 NET_6045 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M147 NET_6045 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M148 PAD NET_61 NET_6028 NET_1370 P33 l=0.300u w=30.000u
M149 NET_6035 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M150 NET_6046 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M151 VDD33 NET_45 NET_86 VDD33 P33 l=0.300u w=5.000u
M152 NET_86 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_3504 NET_6030 NET_1370 P33 l=0.300u w=30.000u
M154 NET_6030 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M155 VDD33 NET_3504 NET_6040 NET_1370 P33 l=0.300u w=30.000u
M156 NET_6040 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M157 VDD33 VSS NET_3504 VDD33 P33 l=0.300u w=5.000u
M158 VDD33 NET_45 NET_85 VDD33 P33 l=0.300u w=5.000u
M159 NET_6011 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M160 NET_6011 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M161 NET_6025 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M162 NET_6025 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M163 NET_45 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_46 NET_6009 NET_1370 P33 l=0.300u w=30.000u
M167 NET_6009 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M168 PAD NET_61 NET_6007 NET_1370 P33 l=0.300u w=30.000u
M169 VDD33 NET_46 NET_6023 NET_1370 P33 l=0.300u w=30.000u
M170 NET_6023 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M171 PAD NET_61 NET_6022 NET_1370 P33 l=0.300u w=30.000u
M172 NET_6006 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M173 NET_6021 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M174 NET_6007 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M175 NET_6022 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M176 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M177 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M181 PAD NET_61 NET_6004 NET_1370 P33 l=0.300u w=30.000u
M182 NET_6004 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M183 PAD NET_61 NET_6019 NET_1370 P33 l=0.300u w=30.000u
M184 NET_6019 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M185 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M186 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M187 VDD33 PAD NET_1370 NET_1370 P33 l=0.350u w=5.000u
M188 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M189 NET_6032 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M190 NET_6028 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M191 NET_6006 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M192 NET_6021 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M193 PAD VDD33 NET_1370 NET_1370 P33 l=0.350u w=15.000u
M194 PAD VDD33 NET_61 NET_1370 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBCD8

.subckt PBCD4   PAD OEN I C REN FP
M1 VSS REN NET_101 VSS N18 l=0.180u w=2.000u
M2 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M4 C NET_111 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M6 C NET_111 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_114 NET_111 VSS N18 l=0.180u w=2.000u
M9 VSS NET_114 NET_111 VSS N18 l=0.180u w=2.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M12 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M18 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M21 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_101 VSS N18 l=0.180u w=2.000u
M23 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_114 NET_111 VDD P18 l=0.180u w=5.000u
M25 VDD NET_114 NET_111 VDD P18 l=0.180u w=5.000u
M26 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M27 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_101 VDD P18 l=0.180u w=5.000u
M29 VDD REN NET_101 VDD P18 l=0.180u w=5.000u
M30 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M31 C NET_111 VDD VDD P18 l=0.180u w=5.000u
M32 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M33 C NET_111 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M36 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M37 NET_6065 OEN NET_74 VDD P18 l=0.180u w=5.000u
M38 NET_6065 I VDD VDD P18 l=0.180u w=5.000u
M39 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M40 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M41 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M42 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M43 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M46 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M47 NET_41 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_31 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_11 NET_29 VSSD N33 l=0.400u w=28.000u
M52 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M54 NET_27 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_43 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_38 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_11 NET_36 VSSD N33 l=0.400u w=28.000u
M60 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M62 NET_34 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M63 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M64 NET_17 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_17 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M66 VSSD NET_11 NET_15 VSSD N33 l=0.400u w=28.000u
M67 NET_15 FP PAD VSSD N33 l=0.400u w=28.000u
M68 PAD FP NET_13 VSSD N33 l=0.400u w=28.000u
M69 NET_13 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M70 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_23 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_23 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_11 NET_21 VSSD N33 l=0.400u w=28.000u
M74 NET_21 FP PAD VSSD N33 l=0.400u w=28.000u
M75 PAD FP NET_19 VSSD N33 l=0.400u w=28.000u
M76 NET_19 NET_11 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD VDD33 NET_11 VSSD N33 l=0.350u w=4.000u
M78 VSSD NET_11 NET_25 VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_11 NET_32 VSSD N33 l=0.400u w=28.000u
M80 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M81 NET_87 NET_45 VSS VSS N33 l=0.350u w=4.000u
M82 NET_87 NET_45 VSS VSS N33 l=0.350u w=4.000u
M83 VSS NET_45 NET_87 VSS N33 l=0.350u w=4.000u
M84 VSS REN NET_90 VSS N33 l=0.350u w=8.000u
M85 VSS NET_101 NET_91 VSS N33 l=0.350u w=8.000u
M86 NET_44 VDD33 NET_93 VSS N33 l=0.350u w=8.000u
M87 NET_44 VDD33 NET_93 VSS N33 l=0.350u w=8.000u
M88 NET_93 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M89 VSS NET_93 NET_97 VSS N33 l=0.350u w=8.000u
M90 NET_93 NET_90 VSS VSS N33 l=4.550u w=0.800u
M91 VSS NET_97 NET_114 VSS N33 l=0.350u w=2.000u
M92 VSS NET_97 NET_114 VSS N33 l=0.350u w=2.000u
M93 VSS NET_49 NET_46 VSS N33 l=0.350u w=8.000u
M94 VSS NET_49 NET_46 VSS N33 l=0.350u w=8.000u
M95 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M96 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M97 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M98 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M99 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M100 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M101 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M102 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M103 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M104 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M105 NET_63 NET_3514 NET_61 VSS N33 l=0.350u w=8.000u
M106 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M107 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M108 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M109 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M110 NET_6036 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M111 NET_6036 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M112 NET_6040 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M113 NET_6040 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M114 NET_1371 NET_1371 NET_1371 NET_1371 P33 l=1.070u w=5.000u
M115 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M116 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M117 NET_114 NET_97 VDD VDD P33 l=0.300u w=5.000u
M118 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M119 NET_97 NET_93 NET_3549 VDD33 P33 l=0.300u w=5.000u
M120 NET_97 NET_93 NET_3549 VDD33 P33 l=0.300u w=5.000u
M121 NET_97 NET_93 NET_3549 VDD33 P33 l=0.300u w=5.000u
M122 NET_97 NET_93 NET_3549 VDD33 P33 l=0.300u w=5.000u
M123 NET_3549 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M124 VDD33 NET_44 NET_3549 VDD33 P33 l=0.300u w=5.000u
M125 NET_3549 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M126 PAD NET_61 NET_6024 NET_1371 P33 l=0.300u w=30.000u
M127 VDD33 NET_3514 NET_6024 NET_1371 P33 l=0.300u w=30.000u
M128 VDD33 NET_3514 NET_6022 NET_1371 P33 l=0.300u w=30.000u
M129 NET_6022 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M130 PAD NET_61 NET_6034 NET_1371 P33 l=0.300u w=30.000u
M131 VDD33 NET_3514 NET_6034 NET_1371 P33 l=0.300u w=30.000u
M132 VDD33 NET_3514 NET_6033 NET_1371 P33 l=0.300u w=30.000u
M133 NET_6033 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M134 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M135 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M136 NET_114 NET_97 VDD VDD P33 l=0.300u w=5.000u
M137 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M138 PAD NET_61 NET_6020 NET_1371 P33 l=0.300u w=30.000u
M139 PAD NET_61 NET_6031 NET_1371 P33 l=0.300u w=30.000u
M140 NET_87 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 NET_87 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_90 NET_91 VDD33 P33 l=0.300u w=5.000u
M143 VDD33 NET_91 NET_90 VDD33 P33 l=0.300u w=5.000u
M144 NET_6019 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M145 NET_6019 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M146 PAD NET_61 NET_6017 NET_1371 P33 l=0.300u w=30.000u
M147 NET_6030 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M148 NET_6030 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M149 PAD NET_61 NET_6013 NET_1371 P33 l=0.300u w=30.000u
M150 NET_6020 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M151 NET_6031 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M152 VDD33 NET_45 NET_87 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_3514 NET_6015 NET_1371 P33 l=0.300u w=30.000u
M154 NET_6015 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M155 VDD33 NET_3514 NET_6025 NET_1371 P33 l=0.300u w=30.000u
M156 NET_6025 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M157 VDD33 VSS NET_3514 VDD33 P33 l=0.300u w=5.000u
M158 VDD33 NET_45 NET_85 VDD33 P33 l=0.300u w=5.000u
M159 NET_5996 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M160 NET_5996 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M161 NET_6010 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M162 NET_6010 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M163 NET_45 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_3514 NET_5994 NET_1371 P33 l=0.300u w=30.000u
M167 NET_5994 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M168 PAD NET_61 NET_5992 NET_1371 P33 l=0.300u w=30.000u
M169 VDD33 NET_3514 NET_6008 NET_1371 P33 l=0.300u w=30.000u
M170 NET_6008 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M171 PAD NET_61 NET_6007 NET_1371 P33 l=0.300u w=30.000u
M172 NET_5991 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M173 NET_6006 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M174 NET_5992 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M175 NET_6007 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M176 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M180 PAD NET_61 NET_5989 NET_1371 P33 l=0.300u w=30.000u
M181 NET_5989 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M182 PAD NET_61 NET_6004 NET_1371 P33 l=0.300u w=30.000u
M183 NET_6004 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M184 NET_1371 PAD VDD33 NET_1371 P33 l=0.350u w=5.000u
M185 NET_1371 PAD VDD33 NET_1371 P33 l=0.350u w=5.000u
M186 VDD33 PAD NET_1371 NET_1371 P33 l=0.350u w=5.000u
M187 VDD33 NET_44 NET_3549 VDD33 P33 l=0.300u w=5.000u
M188 NET_6017 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M189 NET_6013 NET_3514 VDD33 NET_1371 P33 l=0.300u w=30.000u
M190 NET_5991 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M191 NET_6006 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M192 PAD VDD33 NET_1371 NET_1371 P33 l=0.350u w=15.000u
M193 PAD VDD33 NET_61 NET_1371 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBCD4

.subckt PBCD24   PAD OEN I C REN FP
M1 VSS REN NET_101 VSS N18 l=0.180u w=2.000u
M2 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M4 C NET_111 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M6 C NET_111 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_111 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_114 NET_111 VSS N18 l=0.180u w=2.000u
M9 VSS NET_114 NET_111 VSS N18 l=0.180u w=2.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M12 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M18 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M21 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_101 VSS N18 l=0.180u w=2.000u
M23 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_114 NET_111 VDD P18 l=0.180u w=5.000u
M25 VDD NET_114 NET_111 VDD P18 l=0.180u w=5.000u
M26 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M27 VDD REN NET_101 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_101 VDD P18 l=0.180u w=5.000u
M29 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M30 C NET_111 VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M32 C NET_111 VDD VDD P18 l=0.180u w=5.000u
M33 VDD NET_111 C VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M36 NET_6083 OEN NET_74 VDD P18 l=0.180u w=5.000u
M37 NET_6083 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M39 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M40 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M41 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M42 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M43 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M44 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M45 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M46 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M47 NET_41 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M48 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M50 NET_31 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M51 VSSD NET_87 NET_29 VSSD N33 l=0.400u w=28.000u
M52 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M53 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M54 NET_27 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M55 NET_43 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M56 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M57 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M58 NET_38 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_87 NET_36 VSSD N33 l=0.400u w=28.000u
M60 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M61 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M62 NET_34 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M63 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M64 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M65 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M67 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M68 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M69 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M70 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_22 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_87 NET_20 VSSD N33 l=0.400u w=28.000u
M74 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M75 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M76 NET_18 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M77 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M78 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_87 NET_32 VSSD N33 l=0.400u w=28.000u
M80 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M81 NET_87 NET_45 VSS VSS N33 l=0.350u w=8.000u
M82 NET_87 NET_45 VSS VSS N33 l=0.350u w=8.000u
M83 VSS NET_45 NET_87 VSS N33 l=0.350u w=8.000u
M84 VSS REN NET_90 VSS N33 l=0.350u w=8.000u
M85 VSS NET_101 NET_91 VSS N33 l=0.350u w=8.000u
M86 NET_44 VDD33 NET_93 VSS N33 l=0.350u w=8.000u
M87 NET_44 VDD33 NET_93 VSS N33 l=0.350u w=8.000u
M88 NET_93 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M89 VSS NET_93 NET_97 VSS N33 l=0.350u w=8.000u
M90 NET_93 NET_90 VSS VSS N33 l=4.550u w=0.800u
M91 VSS NET_97 NET_114 VSS N33 l=0.350u w=2.000u
M92 VSS NET_97 NET_114 VSS N33 l=0.350u w=2.000u
M93 VSS NET_49 NET_46 VSS N33 l=0.350u w=8.000u
M94 VSS NET_49 NET_46 VSS N33 l=0.350u w=8.000u
M95 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M96 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M97 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M98 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M99 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M100 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M101 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M102 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M103 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M104 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M105 NET_63 NET_3509 NET_61 VSS N33 l=0.350u w=8.000u
M106 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M107 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M108 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M109 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M110 NET_6051 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M111 NET_6051 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M112 NET_6055 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M113 NET_6055 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M114 NET_1371 NET_1371 NET_1371 NET_1371 P33 l=1.070u w=5.000u
M115 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M116 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M117 NET_114 NET_97 VDD VDD P33 l=0.300u w=5.000u
M118 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M119 PAD NET_61 NET_6045 NET_1371 P33 l=0.300u w=30.000u
M120 VDD33 NET_46 NET_6045 NET_1371 P33 l=0.300u w=30.000u
M121 VDD33 NET_46 NET_6043 NET_1371 P33 l=0.300u w=30.000u
M122 NET_6043 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M123 PAD NET_61 NET_6049 NET_1371 P33 l=0.300u w=30.000u
M124 VDD33 NET_46 NET_6049 NET_1371 P33 l=0.300u w=30.000u
M125 VDD33 NET_46 NET_6048 NET_1371 P33 l=0.300u w=30.000u
M126 NET_6048 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M127 NET_97 NET_93 NET_3537 VDD33 P33 l=0.300u w=5.000u
M128 NET_97 NET_93 NET_3537 VDD33 P33 l=0.300u w=5.000u
M129 NET_97 NET_93 NET_3537 VDD33 P33 l=0.300u w=5.000u
M130 NET_97 NET_93 NET_3537 VDD33 P33 l=0.300u w=5.000u
M131 NET_3537 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M132 VDD33 NET_44 NET_3537 VDD33 P33 l=0.300u w=5.000u
M133 NET_3537 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M134 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M135 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M136 NET_114 NET_97 VDD VDD P33 l=0.300u w=5.000u
M137 VDD NET_97 NET_114 VDD P33 l=0.300u w=5.000u
M138 PAD NET_61 NET_6041 NET_1371 P33 l=0.300u w=30.000u
M139 PAD NET_61 NET_6046 NET_1371 P33 l=0.300u w=30.000u
M140 NET_6035 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M141 NET_6035 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M142 PAD NET_61 NET_6033 NET_1371 P33 l=0.300u w=30.000u
M143 NET_6039 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M144 NET_6039 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M145 PAD NET_61 NET_6030 NET_1371 P33 l=0.300u w=30.000u
M146 NET_87 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M147 NET_87 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M148 VDD33 NET_90 NET_91 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_91 NET_90 VDD33 P33 l=0.300u w=5.000u
M150 NET_6041 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M151 NET_6046 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M152 VDD33 NET_46 NET_6031 NET_1371 P33 l=0.300u w=30.000u
M153 NET_6031 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M154 VDD33 NET_46 NET_6036 NET_1371 P33 l=0.300u w=30.000u
M155 NET_6036 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M156 VDD33 NET_45 NET_87 VDD33 P33 l=0.300u w=5.000u
M157 NET_6025 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M158 NET_6025 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M159 NET_6029 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M160 NET_6029 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M161 VDD33 VSS NET_3509 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_45 NET_85 VDD33 P33 l=0.300u w=5.000u
M163 NET_45 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_46 NET_6023 NET_1371 P33 l=0.300u w=30.000u
M165 NET_6023 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M166 PAD NET_61 NET_6021 NET_1371 P33 l=0.300u w=30.000u
M167 VDD33 NET_46 NET_6027 NET_1371 P33 l=0.300u w=30.000u
M168 NET_6027 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M169 PAD NET_61 NET_6026 NET_1371 P33 l=0.300u w=30.000u
M170 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M172 NET_6011 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M173 NET_6019 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M174 NET_6021 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M175 NET_6026 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M176 PAD NET_61 NET_6009 NET_1371 P33 l=0.300u w=30.000u
M177 NET_6009 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M178 PAD NET_61 NET_6017 NET_1371 P33 l=0.300u w=30.000u
M179 NET_6017 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M180 NET_1371 PAD VDD33 NET_1371 P33 l=0.350u w=5.000u
M181 NET_1371 PAD VDD33 NET_1371 P33 l=0.350u w=5.000u
M182 VDD33 PAD NET_1371 NET_1371 P33 l=0.350u w=5.000u
M183 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M184 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M185 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M186 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M187 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M188 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M189 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M190 VDD33 NET_44 NET_3537 VDD33 P33 l=0.300u w=5.000u
M191 NET_6033 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M192 NET_6030 NET_46 VDD33 NET_1371 P33 l=0.300u w=30.000u
M193 NET_6011 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M194 NET_6019 NET_61 PAD NET_1371 P33 l=0.300u w=30.000u
M195 PAD VDD33 NET_1371 NET_1371 P33 l=0.350u w=15.000u
M196 PAD VDD33 NET_61 NET_1371 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBCD24

.subckt PBCD2   PAD OEN I C REN FP
M1 VSS REN NET_84 VSS N18 l=0.180u w=2.000u
M2 VSS NET_112 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_112 C VSS N18 l=0.180u w=2.000u
M4 C NET_112 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_112 C VSS N18 l=0.180u w=2.000u
M6 C NET_112 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_112 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_115 NET_112 VSS N18 l=0.180u w=2.000u
M9 VSS NET_115 NET_112 VSS N18 l=0.180u w=2.000u
M10 VSS NET_71 NET_67 VSS N18 l=0.180u w=4.000u
M11 VSS NET_71 NET_67 VSS N18 l=0.180u w=4.000u
M12 NET_72 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_72 NET_73 NET_71 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_76 VSS N18 l=0.180u w=2.000u
M18 NET_76 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_76 VSS N18 l=0.180u w=2.000u
M20 VSS NET_76 NET_10 VSS N18 l=0.180u w=2.000u
M21 VSS NET_76 NET_10 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_84 VSS N18 l=0.180u w=2.000u
M23 VDD NET_112 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_115 NET_112 VDD P18 l=0.180u w=5.000u
M25 VDD NET_115 NET_112 VDD P18 l=0.180u w=5.000u
M26 VDD NET_76 NET_10 VDD P18 l=0.180u w=5.000u
M27 VDD NET_76 NET_10 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_84 VDD P18 l=0.180u w=5.000u
M29 VDD REN NET_84 VDD P18 l=0.180u w=5.000u
M30 VDD NET_112 C VDD P18 l=0.180u w=5.000u
M31 C NET_112 VDD VDD P18 l=0.180u w=5.000u
M32 VDD NET_112 C VDD P18 l=0.180u w=5.000u
M33 C NET_112 VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_112 C VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_73 VDD P18 l=0.180u w=5.000u
M36 VDD OEN NET_73 VDD P18 l=0.180u w=5.000u
M37 NET_6056 OEN NET_76 VDD P18 l=0.180u w=5.000u
M38 NET_6056 I VDD VDD P18 l=0.180u w=5.000u
M39 VDD NET_76 NET_10 VDD P18 l=0.180u w=5.000u
M40 VDD NET_76 NET_10 VDD P18 l=0.180u w=5.000u
M41 VDD NET_71 NET_67 VDD P18 l=0.180u w=5.000u
M42 VDD NET_71 NET_67 VDD P18 l=0.180u w=5.000u
M43 NET_71 I VDD VDD P18 l=0.180u w=5.000u
M44 NET_71 I VDD VDD P18 l=0.180u w=5.000u
M45 VDD NET_73 NET_71 VDD P18 l=0.180u w=5.000u
M46 NET_71 NET_73 VDD VDD P18 l=0.180u w=5.000u
M47 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M51 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M52 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M53 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M55 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M56 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M58 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M60 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M65 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M67 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_41 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M78 NET_43 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M80 NET_86 NET_10 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_66 NET_87 VSS N33 l=0.350u w=4.000u
M82 VSS NET_66 NET_87 VSS N33 l=0.350u w=4.000u
M83 VSS NET_48 NET_45 VSS N33 l=0.350u w=4.000u
M84 VSS NET_48 NET_45 VSS N33 l=0.350u w=4.000u
M85 VSS NET_71 NET_48 VSS N33 l=0.350u w=5.330u
M86 VSS NET_71 NET_48 VSS N33 l=0.350u w=5.330u
M87 NET_48 NET_71 VSS VSS N33 l=0.350u w=5.330u
M88 VSS NET_67 NET_49 VSS N33 l=0.350u w=5.330u
M89 NET_49 NET_67 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_67 NET_49 VSS N33 l=0.350u w=5.330u
M91 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M92 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M93 VSS NET_73 NET_57 VSS N33 l=0.350u w=7.440u
M94 NET_57 NET_73 VSS VSS N33 l=0.350u w=7.440u
M95 NET_62 NET_3516 NET_60 VSS N33 l=0.350u w=8.000u
M96 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M97 NET_86 NET_10 VSS VSS N33 l=0.350u w=8.000u
M98 VSS NET_76 NET_66 VSS N33 l=0.350u w=8.000u
M99 VSS NET_76 NET_66 VSS N33 l=0.350u w=8.000u
M100 VSS REN NET_90 VSS N33 l=0.350u w=8.000u
M101 VSS NET_84 NET_91 VSS N33 l=0.350u w=8.000u
M102 NET_44 VDD33 NET_93 VSS N33 l=0.350u w=8.000u
M103 NET_44 VDD33 NET_93 VSS N33 l=0.350u w=8.000u
M104 NET_93 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M105 VSS NET_93 NET_97 VSS N33 l=0.350u w=8.000u
M106 NET_93 NET_90 VSS VSS N33 l=4.550u w=0.800u
M107 VSS NET_97 NET_115 VSS N33 l=0.350u w=2.000u
M108 VSS NET_97 NET_115 VSS N33 l=0.350u w=2.000u
M109 NET_6026 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M110 NET_6026 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M111 NET_6030 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M112 NET_6030 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M113 NET_1370 NET_1370 NET_1370 NET_1370 P33 l=1.070u w=5.000u
M114 VDD NET_97 NET_115 VDD P33 l=0.300u w=5.000u
M115 VDD NET_97 NET_115 VDD P33 l=0.300u w=5.000u
M116 NET_115 NET_97 VDD VDD P33 l=0.300u w=5.000u
M117 VDD NET_97 NET_115 VDD P33 l=0.300u w=5.000u
M118 NET_97 NET_93 NET_3557 VDD33 P33 l=0.300u w=5.000u
M119 NET_97 NET_93 NET_3557 VDD33 P33 l=0.300u w=5.000u
M120 NET_97 NET_93 NET_3557 VDD33 P33 l=0.300u w=5.000u
M121 NET_97 NET_93 NET_3557 VDD33 P33 l=0.300u w=5.000u
M122 NET_3557 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_44 NET_3557 VDD33 P33 l=0.300u w=5.000u
M124 NET_3557 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 PAD NET_60 NET_6014 NET_1370 P33 l=0.300u w=30.000u
M126 VDD33 NET_3516 NET_6014 NET_1370 P33 l=0.300u w=30.000u
M127 VDD33 NET_3516 NET_6012 NET_1370 P33 l=0.300u w=30.000u
M128 NET_6012 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M129 PAD NET_60 NET_6024 NET_1370 P33 l=0.300u w=30.000u
M130 VDD33 NET_3516 NET_6024 NET_1370 P33 l=0.300u w=30.000u
M131 VDD33 NET_3516 NET_6023 NET_1370 P33 l=0.300u w=30.000u
M132 NET_6023 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M133 VDD NET_97 NET_115 VDD P33 l=0.300u w=5.000u
M134 VDD NET_97 NET_115 VDD P33 l=0.300u w=5.000u
M135 NET_115 NET_97 VDD VDD P33 l=0.300u w=5.000u
M136 VDD NET_97 NET_115 VDD P33 l=0.300u w=5.000u
M137 PAD NET_60 NET_6010 NET_1370 P33 l=0.300u w=30.000u
M138 PAD NET_60 NET_6021 NET_1370 P33 l=0.300u w=30.000u
M139 VDD33 NET_90 NET_91 VDD33 P33 l=0.300u w=5.000u
M140 VDD33 NET_91 NET_90 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_66 NET_87 VDD33 P33 l=0.300u w=5.000u
M142 NET_6009 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M143 NET_6009 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M144 PAD NET_60 NET_6007 NET_1370 P33 l=0.300u w=30.000u
M145 NET_6020 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M146 NET_6020 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M147 PAD NET_60 NET_6003 NET_1370 P33 l=0.300u w=30.000u
M148 NET_6010 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M149 NET_6021 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M150 VDD33 NET_3516 NET_6005 NET_1370 P33 l=0.300u w=30.000u
M151 NET_6005 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M152 VDD33 NET_3516 NET_6015 NET_1370 P33 l=0.300u w=30.000u
M153 NET_6015 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M154 VDD33 VSS NET_3516 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_66 NET_86 VDD33 P33 l=0.300u w=5.000u
M156 NET_5986 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M157 NET_5986 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M158 NET_6000 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M159 NET_6000 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M160 NET_66 NET_86 VDD33 VDD33 P33 l=0.300u w=5.000u
M161 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M163 VDD33 NET_3516 NET_5984 NET_1370 P33 l=0.300u w=30.000u
M164 NET_5984 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M165 PAD NET_60 NET_5982 NET_1370 P33 l=0.300u w=30.000u
M166 VDD33 NET_3516 NET_5998 NET_1370 P33 l=0.300u w=30.000u
M167 NET_5998 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M168 PAD NET_60 NET_5997 NET_1370 P33 l=0.300u w=30.000u
M169 NET_5981 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M170 NET_5996 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M171 NET_5982 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M172 NET_5997 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M173 NET_45 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M174 NET_45 NET_48 VDD33 VDD33 P33 l=0.300u w=5.000u
M175 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M177 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M178 PAD NET_60 NET_5979 NET_1370 P33 l=0.300u w=30.000u
M179 NET_5979 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M180 PAD NET_60 NET_5994 NET_1370 P33 l=0.300u w=30.000u
M181 NET_5994 NET_45 VDD33 NET_1370 P33 l=0.300u w=30.000u
M182 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M183 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M184 VDD33 PAD NET_1370 NET_1370 P33 l=0.350u w=5.000u
M185 VDD33 NET_44 NET_3557 VDD33 P33 l=0.300u w=5.000u
M186 NET_6007 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M187 NET_6003 NET_3516 VDD33 NET_1370 P33 l=0.300u w=30.000u
M188 NET_5981 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M189 NET_5996 NET_60 PAD NET_1370 P33 l=0.300u w=30.000u
M190 PAD VDD33 NET_1370 NET_1370 P33 l=0.350u w=15.000u
M191 PAD VDD33 NET_60 NET_1370 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBCD2

.subckt PBCD16   PAD OEN I C REN FP
M1 VSS REN NET_100 VSS N18 l=0.180u w=2.000u
M2 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M4 C NET_110 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M6 C NET_110 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_113 NET_110 VSS N18 l=0.180u w=2.000u
M9 VSS NET_113 NET_110 VSS N18 l=0.180u w=2.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M12 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M18 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M21 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_100 VSS N18 l=0.180u w=2.000u
M23 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_113 NET_110 VDD P18 l=0.180u w=5.000u
M25 VDD NET_113 NET_110 VDD P18 l=0.180u w=5.000u
M26 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M27 VDD REN NET_100 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_100 VDD P18 l=0.180u w=5.000u
M29 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M30 C NET_110 VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M32 C NET_110 VDD VDD P18 l=0.180u w=5.000u
M33 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M36 NET_6081 OEN NET_74 VDD P18 l=0.180u w=5.000u
M37 NET_6081 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M39 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M40 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M41 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M42 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M43 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M44 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M45 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M46 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M47 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_31 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_86 NET_29 VSSD N33 l=0.400u w=28.000u
M51 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M52 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M53 NET_27 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M55 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M56 NET_38 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_86 NET_36 VSSD N33 l=0.400u w=28.000u
M58 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M60 NET_34 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M65 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M67 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_41 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M78 NET_43 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M80 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_45 NET_86 VSS N33 l=0.350u w=8.000u
M82 VSS NET_45 NET_86 VSS N33 l=0.350u w=8.000u
M83 VSS NET_49 NET_46 VSS N33 l=0.350u w=10.000u
M84 VSS NET_49 NET_46 VSS N33 l=0.350u w=10.000u
M85 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M86 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M87 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M88 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M89 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M91 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M92 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M93 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M94 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M95 NET_63 NET_3504 NET_61 VSS N33 l=0.350u w=8.000u
M96 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M97 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M98 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M99 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M100 VSS REN NET_89 VSS N33 l=0.350u w=8.000u
M101 VSS NET_100 NET_90 VSS N33 l=0.350u w=8.000u
M102 NET_44 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M103 NET_44 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M104 NET_92 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M105 VSS NET_92 NET_96 VSS N33 l=0.350u w=8.000u
M106 NET_92 NET_89 VSS VSS N33 l=4.550u w=0.800u
M107 VSS NET_96 NET_113 VSS N33 l=0.350u w=2.000u
M108 VSS NET_96 NET_113 VSS N33 l=0.350u w=2.000u
M109 NET_6051 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M110 NET_6051 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M111 NET_6055 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M112 NET_6055 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M113 NET_1370 NET_1370 NET_1370 NET_1370 P33 l=1.070u w=5.000u
M114 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M115 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M116 NET_113 NET_96 VDD VDD P33 l=0.300u w=5.000u
M117 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M118 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M119 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M120 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M121 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M122 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M124 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 PAD NET_61 NET_6039 NET_1370 P33 l=0.300u w=30.000u
M126 VDD33 NET_3504 NET_6039 NET_1370 P33 l=0.300u w=30.000u
M127 VDD33 NET_3504 NET_6037 NET_1370 P33 l=0.300u w=30.000u
M128 NET_6037 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M129 PAD NET_61 NET_6049 NET_1370 P33 l=0.300u w=30.000u
M130 VDD33 NET_3504 NET_6049 NET_1370 P33 l=0.300u w=30.000u
M131 VDD33 NET_3504 NET_6048 NET_1370 P33 l=0.300u w=30.000u
M132 NET_6048 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M133 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M134 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M135 NET_113 NET_96 VDD VDD P33 l=0.300u w=5.000u
M136 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M137 PAD NET_61 NET_6035 NET_1370 P33 l=0.300u w=30.000u
M138 PAD NET_61 NET_6046 NET_1370 P33 l=0.300u w=30.000u
M139 NET_86 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M140 NET_86 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_89 NET_90 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_90 NET_89 VDD33 P33 l=0.300u w=5.000u
M143 NET_6034 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M144 NET_6034 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M145 PAD NET_61 NET_6032 NET_1370 P33 l=0.300u w=30.000u
M146 NET_6045 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M147 NET_6045 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M148 PAD NET_61 NET_6028 NET_1370 P33 l=0.300u w=30.000u
M149 NET_6035 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M150 NET_6046 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M151 VDD33 NET_45 NET_86 VDD33 P33 l=0.300u w=5.000u
M152 NET_86 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_46 NET_6030 NET_1370 P33 l=0.300u w=30.000u
M154 NET_6030 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M155 VDD33 NET_46 NET_6040 NET_1370 P33 l=0.300u w=30.000u
M156 NET_6040 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M157 VDD33 VSS NET_3504 VDD33 P33 l=0.300u w=5.000u
M158 VDD33 NET_45 NET_85 VDD33 P33 l=0.300u w=5.000u
M159 NET_6011 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M160 NET_6011 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M161 NET_6025 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M162 NET_6025 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M163 NET_45 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_46 NET_6009 NET_1370 P33 l=0.300u w=30.000u
M167 NET_6009 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M168 PAD NET_61 NET_6007 NET_1370 P33 l=0.300u w=30.000u
M169 VDD33 NET_46 NET_6023 NET_1370 P33 l=0.300u w=30.000u
M170 NET_6023 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M171 PAD NET_61 NET_6022 NET_1370 P33 l=0.300u w=30.000u
M172 NET_6006 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M173 NET_6021 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M174 NET_6007 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M175 NET_6022 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M176 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M177 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M181 PAD NET_61 NET_6004 NET_1370 P33 l=0.300u w=30.000u
M182 NET_6004 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M183 PAD NET_61 NET_6019 NET_1370 P33 l=0.300u w=30.000u
M184 NET_6019 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M185 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M186 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M187 VDD33 PAD NET_1370 NET_1370 P33 l=0.350u w=5.000u
M188 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M189 NET_6032 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M190 NET_6028 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M191 NET_6006 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M192 NET_6021 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M193 PAD VDD33 NET_1370 NET_1370 P33 l=0.350u w=15.000u
M194 PAD VDD33 NET_61 NET_1370 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBCD16

.subckt PBCD12   PAD OEN I C REN FP
M1 VSS REN NET_100 VSS N18 l=0.180u w=2.000u
M2 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M3 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M4 C NET_110 VSS VSS N18 l=0.180u w=2.000u
M5 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M6 C NET_110 VSS VSS N18 l=0.180u w=2.000u
M7 VSS NET_110 C VSS N18 l=0.180u w=2.000u
M8 VSS NET_113 NET_110 VSS N18 l=0.180u w=2.000u
M9 VSS NET_113 NET_110 VSS N18 l=0.180u w=2.000u
M10 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M11 VSS NET_69 NET_65 VSS N18 l=0.180u w=4.000u
M12 NET_70 I VSS VSS N18 l=0.180u w=4.000u
M13 NET_70 NET_71 NET_69 VSS N18 l=0.180u w=4.000u
M14 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_71 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M17 VSS OEN NET_74 VSS N18 l=0.180u w=2.000u
M18 NET_74 I VSS VSS N18 l=0.180u w=2.000u
M19 VSS I NET_74 VSS N18 l=0.180u w=2.000u
M20 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M21 VSS NET_74 NET_10 VSS N18 l=0.180u w=2.000u
M22 VSS REN NET_100 VSS N18 l=0.180u w=2.000u
M23 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M24 VDD NET_113 NET_110 VDD P18 l=0.180u w=5.000u
M25 VDD NET_113 NET_110 VDD P18 l=0.180u w=5.000u
M26 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M27 VDD REN NET_100 VDD P18 l=0.180u w=5.000u
M28 VDD REN NET_100 VDD P18 l=0.180u w=5.000u
M29 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M30 C NET_110 VDD VDD P18 l=0.180u w=5.000u
M31 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M32 C NET_110 VDD VDD P18 l=0.180u w=5.000u
M33 VDD NET_110 C VDD P18 l=0.180u w=5.000u
M34 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M35 VDD OEN NET_71 VDD P18 l=0.180u w=5.000u
M36 NET_6081 OEN NET_74 VDD P18 l=0.180u w=5.000u
M37 NET_6081 I VDD VDD P18 l=0.180u w=5.000u
M38 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M39 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M40 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M41 VDD NET_69 NET_65 VDD P18 l=0.180u w=5.000u
M42 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M43 NET_69 I VDD VDD P18 l=0.180u w=5.000u
M44 VDD NET_71 NET_69 VDD P18 l=0.180u w=5.000u
M45 NET_69 NET_71 VDD VDD P18 l=0.180u w=5.000u
M46 VDD NET_74 NET_10 VDD P18 l=0.180u w=5.000u
M47 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M48 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M49 NET_31 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M50 VSSD NET_86 NET_29 VSSD N33 l=0.400u w=28.000u
M51 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M52 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M53 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M54 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M55 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M56 NET_38 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M57 VSSD NET_86 NET_36 VSSD N33 l=0.400u w=28.000u
M58 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M59 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M60 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M61 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M63 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M64 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M65 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M66 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M67 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_41 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M77 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M78 NET_43 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M79 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M80 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M81 VSS NET_45 NET_86 VSS N33 l=0.350u w=8.000u
M82 VSS NET_45 NET_86 VSS N33 l=0.350u w=8.000u
M83 VSS NET_49 NET_46 VSS N33 l=0.350u w=10.000u
M84 VSS NET_49 NET_46 VSS N33 l=0.350u w=10.000u
M85 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M86 VSS NET_69 NET_49 VSS N33 l=0.350u w=5.330u
M87 NET_49 NET_69 VSS VSS N33 l=0.350u w=5.330u
M88 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M89 NET_50 NET_65 VSS VSS N33 l=0.350u w=5.330u
M90 VSS NET_65 NET_50 VSS N33 l=0.350u w=5.330u
M91 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M92 NET_60 OEN VSS VSS N33 l=0.350u w=7.440u
M93 VSS NET_71 NET_58 VSS N33 l=0.350u w=7.440u
M94 NET_58 NET_71 VSS VSS N33 l=0.350u w=7.440u
M95 NET_63 NET_3504 NET_61 VSS N33 l=0.350u w=8.000u
M96 NET_63 NET_60 VSS VSS N33 l=0.350u w=8.000u
M97 NET_85 NET_10 VSS VSS N33 l=0.350u w=8.000u
M98 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M99 VSS NET_74 NET_45 VSS N33 l=0.350u w=8.000u
M100 VSS REN NET_89 VSS N33 l=0.350u w=8.000u
M101 VSS NET_100 NET_90 VSS N33 l=0.350u w=8.000u
M102 NET_44 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M103 NET_44 VDD33 NET_92 VSS N33 l=0.350u w=8.000u
M104 NET_92 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M105 VSS NET_92 NET_96 VSS N33 l=0.350u w=8.000u
M106 NET_92 NET_89 VSS VSS N33 l=4.550u w=0.800u
M107 VSS NET_96 NET_113 VSS N33 l=0.350u w=2.000u
M108 VSS NET_96 NET_113 VSS N33 l=0.350u w=2.000u
M109 NET_6051 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M110 NET_6051 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M111 NET_6055 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M112 NET_6055 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M113 NET_1370 NET_1370 NET_1370 NET_1370 P33 l=1.070u w=5.000u
M114 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M115 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M116 NET_113 NET_96 VDD VDD P33 l=0.300u w=5.000u
M117 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M118 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M119 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M120 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M121 NET_96 NET_92 NET_3540 VDD33 P33 l=0.300u w=5.000u
M122 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M124 NET_3540 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 PAD NET_61 NET_6039 NET_1370 P33 l=0.300u w=30.000u
M126 VDD33 NET_3504 NET_6039 NET_1370 P33 l=0.300u w=30.000u
M127 VDD33 NET_3504 NET_6037 NET_1370 P33 l=0.300u w=30.000u
M128 NET_6037 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M129 PAD NET_61 NET_6049 NET_1370 P33 l=0.300u w=30.000u
M130 VDD33 NET_3504 NET_6049 NET_1370 P33 l=0.300u w=30.000u
M131 VDD33 NET_3504 NET_6048 NET_1370 P33 l=0.300u w=30.000u
M132 NET_6048 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M133 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M134 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M135 NET_113 NET_96 VDD VDD P33 l=0.300u w=5.000u
M136 VDD NET_96 NET_113 VDD P33 l=0.300u w=5.000u
M137 PAD NET_61 NET_6035 NET_1370 P33 l=0.300u w=30.000u
M138 PAD NET_61 NET_6046 NET_1370 P33 l=0.300u w=30.000u
M139 NET_86 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M140 NET_86 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M141 VDD33 NET_89 NET_90 VDD33 P33 l=0.300u w=5.000u
M142 VDD33 NET_90 NET_89 VDD33 P33 l=0.300u w=5.000u
M143 NET_6034 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M144 NET_6034 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M145 PAD NET_61 NET_6032 NET_1370 P33 l=0.300u w=30.000u
M146 NET_6045 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M147 NET_6045 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M148 PAD NET_61 NET_6028 NET_1370 P33 l=0.300u w=30.000u
M149 NET_6035 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M150 NET_6046 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M151 VDD33 NET_45 NET_86 VDD33 P33 l=0.300u w=5.000u
M152 NET_86 NET_45 VDD33 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_46 NET_6030 NET_1370 P33 l=0.300u w=30.000u
M154 NET_6030 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M155 VDD33 NET_46 NET_6040 NET_1370 P33 l=0.300u w=30.000u
M156 NET_6040 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M157 VDD33 VSS NET_3504 VDD33 P33 l=0.300u w=5.000u
M158 VDD33 NET_45 NET_85 VDD33 P33 l=0.300u w=5.000u
M159 NET_6011 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M160 NET_6011 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M161 NET_6025 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M162 NET_6025 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M163 NET_45 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M164 VDD33 NET_60 NET_58 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_58 NET_60 VDD33 P33 l=0.300u w=5.000u
M166 VDD33 NET_46 NET_6009 NET_1370 P33 l=0.300u w=30.000u
M167 NET_6009 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M168 PAD NET_61 NET_6007 NET_1370 P33 l=0.300u w=30.000u
M169 VDD33 NET_46 NET_6023 NET_1370 P33 l=0.300u w=30.000u
M170 NET_6023 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M171 PAD NET_61 NET_6022 NET_1370 P33 l=0.300u w=30.000u
M172 NET_6006 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M173 NET_6021 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M174 NET_6007 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M175 NET_6022 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M176 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M177 NET_46 NET_49 VDD33 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_49 NET_46 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_49 NET_50 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_50 NET_49 VDD33 P33 l=0.300u w=5.000u
M181 PAD NET_61 NET_6004 NET_1370 P33 l=0.300u w=30.000u
M182 NET_6004 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M183 PAD NET_61 NET_6019 NET_1370 P33 l=0.300u w=30.000u
M184 NET_6019 NET_46 VDD33 NET_1370 P33 l=0.300u w=30.000u
M185 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M186 NET_1370 PAD VDD33 NET_1370 P33 l=0.350u w=5.000u
M187 VDD33 PAD NET_1370 NET_1370 P33 l=0.350u w=5.000u
M188 VDD33 NET_44 NET_3540 VDD33 P33 l=0.300u w=5.000u
M189 NET_6032 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M190 NET_6028 NET_3504 VDD33 NET_1370 P33 l=0.300u w=30.000u
M191 NET_6006 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M192 NET_6021 NET_61 PAD NET_1370 P33 l=0.300u w=30.000u
M193 PAD VDD33 NET_1370 NET_1370 P33 l=0.350u w=15.000u
M194 PAD VDD33 NET_61 NET_1370 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PBCD12

.subckt PB8   PAD OEN I C FP
M1 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M3 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M5 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M8 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M9 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M10 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_51 NET_52 NET_50 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M17 NET_55 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_55 VSS N18 l=0.180u w=2.000u
M19 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M20 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M21 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M23 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M24 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M25 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M26 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M27 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M28 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M29 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M32 NET_6041 OEN NET_55 VDD P18 l=0.180u w=5.000u
M33 NET_6041 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M35 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M36 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M37 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M38 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_52 NET_50 VDD P18 l=0.180u w=5.000u
M41 NET_50 NET_52 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M62 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M63 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M64 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M65 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M70 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M72 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M74 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M78 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M79 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M80 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M81 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M82 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M83 NET_67 NET_50 VSS VSS N33 l=0.350u w=5.330u
M84 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M85 NET_68 NET_46 VSS VSS N33 l=0.350u w=5.330u
M86 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M87 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M88 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M89 VSS NET_52 NET_76 VSS N33 l=0.350u w=7.440u
M90 NET_76 NET_52 VSS VSS N33 l=0.350u w=7.440u
M91 NET_81 NET_3502 NET_79 VSS N33 l=0.350u w=8.000u
M92 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M93 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M94 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M95 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M98 NET_103 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M99 VSS NET_103 NET_107 VSS N33 l=0.350u w=8.000u
M100 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M101 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M102 NET_6010 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M103 NET_6010 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M104 NET_6012 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M105 NET_6012 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M106 NET_1361 NET_1361 NET_1361 NET_1361 P33 l=1.070u w=5.000u
M107 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M108 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M109 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M110 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M111 NET_107 NET_103 NET_3538 VDD33 P33 l=0.300u w=5.000u
M112 NET_107 NET_103 NET_3538 VDD33 P33 l=0.300u w=5.000u
M113 NET_107 NET_103 NET_3538 VDD33 P33 l=0.300u w=5.000u
M114 NET_107 NET_103 NET_3538 VDD33 P33 l=0.300u w=5.000u
M115 NET_3538 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_44 NET_3538 VDD33 P33 l=0.300u w=5.000u
M117 NET_3538 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M118 PAD NET_79 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M119 VDD33 NET_3502 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M120 VDD33 NET_3502 NET_6001 NET_1361 P33 l=0.300u w=30.000u
M121 NET_6001 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M122 PAD NET_79 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M123 VDD33 NET_3502 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M124 VDD33 NET_3502 NET_6006 NET_1361 P33 l=0.300u w=30.000u
M125 NET_6006 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M126 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M127 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M128 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M130 PAD NET_79 NET_5999 NET_1361 P33 l=0.300u w=30.000u
M131 PAD NET_79 NET_6004 NET_1361 P33 l=0.300u w=30.000u
M132 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M133 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M134 NET_5993 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M135 NET_5993 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M136 PAD NET_79 NET_5991 NET_1361 P33 l=0.300u w=30.000u
M137 NET_5998 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M138 NET_5998 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M139 PAD NET_79 NET_5996 NET_1361 P33 l=0.300u w=30.000u
M140 NET_5999 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M141 NET_6004 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M142 VDD33 NET_82 NET_100 VDD33 P33 l=0.300u w=5.000u
M143 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M144 VDD33 NET_3502 NET_5989 NET_1361 P33 l=0.300u w=30.000u
M145 NET_5989 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M146 VDD33 NET_3502 NET_5994 NET_1361 P33 l=0.300u w=30.000u
M147 NET_5994 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3502 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_82 NET_99 VDD33 P33 l=0.300u w=5.000u
M150 NET_5979 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M151 NET_5979 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M152 NET_5984 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M153 NET_5984 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M154 NET_82 NET_99 VDD33 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M157 VDD33 NET_64 NET_5977 NET_1361 P33 l=0.300u w=30.000u
M158 NET_5977 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M159 PAD NET_79 NET_5975 NET_1361 P33 l=0.300u w=30.000u
M160 VDD33 NET_64 NET_5982 NET_1361 P33 l=0.300u w=30.000u
M161 NET_5982 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M162 PAD NET_79 NET_5980 NET_1361 P33 l=0.300u w=30.000u
M163 NET_5966 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M164 NET_5970 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M165 NET_5975 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M166 NET_5980 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M167 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M168 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M172 PAD NET_79 NET_5964 NET_1361 P33 l=0.300u w=30.000u
M173 NET_5964 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M174 PAD NET_79 NET_5968 NET_1361 P33 l=0.300u w=30.000u
M175 NET_5968 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M176 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M177 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M178 VDD33 PAD NET_1361 NET_1361 P33 l=0.350u w=5.000u
M179 VDD33 NET_44 NET_3538 VDD33 P33 l=0.300u w=5.000u
M180 NET_5991 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M181 NET_5996 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M182 NET_5966 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M183 NET_5970 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_79 NET_1361 P33 l=0.350u w=10.000u
M185 PAD VDD33 NET_1361 NET_1361 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PB8

.subckt PB4   PAD OEN I C FP
M1 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M3 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M5 C NET_103 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_103 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_106 NET_103 VSS N18 l=0.180u w=2.000u
M8 VSS NET_106 NET_103 VSS N18 l=0.180u w=2.000u
M9 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M10 VSS NET_68 NET_64 VSS N18 l=0.180u w=4.000u
M11 NET_69 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_69 NET_70 NET_68 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_70 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_73 VSS N18 l=0.180u w=2.000u
M17 NET_73 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_73 VSS N18 l=0.180u w=2.000u
M19 NET_78 NET_73 VSS VSS N18 l=0.180u w=2.000u
M20 VSS NET_73 NET_78 VSS N18 l=0.180u w=2.000u
M21 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_106 NET_103 VDD P18 l=0.180u w=5.000u
M23 VDD NET_106 NET_103 VDD P18 l=0.180u w=5.000u
M24 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M25 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M26 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M27 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M28 C NET_103 VDD VDD P18 l=0.180u w=5.000u
M29 VDD NET_103 C VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_70 VDD P18 l=0.180u w=5.000u
M32 NET_6025 OEN NET_73 VDD P18 l=0.180u w=5.000u
M33 NET_6025 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M35 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M36 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M37 VDD NET_68 NET_64 VDD P18 l=0.180u w=5.000u
M38 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_68 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_70 NET_68 VDD P18 l=0.180u w=5.000u
M41 NET_68 NET_70 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_73 NET_78 VDD P18 l=0.180u w=5.000u
M43 NET_85 NET_78 VSS VSS N33 l=0.350u w=8.000u
M44 NET_87 NET_10 VSS VSS N33 l=0.350u w=4.000u
M45 NET_87 NET_10 VSS VSS N33 l=0.350u w=4.000u
M46 VSS NET_10 NET_87 VSS N33 l=0.350u w=4.000u
M47 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M48 VSS NET_48 NET_45 VSS N33 l=0.350u w=8.000u
M49 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M50 VSS NET_68 NET_48 VSS N33 l=0.350u w=5.330u
M51 NET_48 NET_68 VSS VSS N33 l=0.350u w=5.330u
M52 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M53 NET_49 NET_64 VSS VSS N33 l=0.350u w=5.330u
M54 VSS NET_64 NET_49 VSS N33 l=0.350u w=5.330u
M55 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M56 NET_59 OEN VSS VSS N33 l=0.350u w=7.440u
M57 VSS NET_70 NET_57 VSS N33 l=0.350u w=7.440u
M58 NET_57 NET_70 VSS VSS N33 l=0.350u w=7.440u
M59 NET_62 NET_3512 NET_60 VSS N33 l=0.350u w=8.000u
M60 NET_62 NET_59 VSS VSS N33 l=0.350u w=8.000u
M61 NET_85 NET_78 VSS VSS N33 l=0.350u w=8.000u
M62 VSS NET_73 NET_10 VSS N33 l=0.350u w=8.000u
M63 VSS NET_73 NET_10 VSS N33 l=0.350u w=8.000u
M64 NET_44 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M65 NET_44 VDD33 NET_90 VSS N33 l=0.350u w=8.000u
M66 NET_90 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M67 VSS NET_90 NET_94 VSS N33 l=0.350u w=8.000u
M68 VSS NET_94 NET_106 VSS N33 l=0.350u w=2.000u
M69 VSS NET_94 NET_106 VSS N33 l=0.350u w=2.000u
M70 NET_41 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M71 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M73 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M74 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M75 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M76 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M77 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M78 NET_43 NET_87 VSSD VSSD N33 l=0.400u w=28.000u
M79 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M80 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M81 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M82 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M83 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M84 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M85 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M86 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M87 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M88 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M89 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M90 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M91 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M92 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M93 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M94 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M95 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M96 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M97 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M98 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M99 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M100 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M101 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M102 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M103 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M104 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M105 NET_106 NET_94 VDD VDD P33 l=0.300u w=5.000u
M106 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M107 NET_5995 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M108 NET_5995 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M109 NET_5997 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M110 NET_5997 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M111 NET_1362 NET_1362 NET_1362 NET_1362 P33 l=1.070u w=5.000u
M112 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M113 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M114 NET_106 NET_94 VDD VDD P33 l=0.300u w=5.000u
M115 VDD NET_94 NET_106 VDD P33 l=0.300u w=5.000u
M116 NET_94 NET_90 NET_3553 VDD33 P33 l=0.300u w=5.000u
M117 NET_94 NET_90 NET_3553 VDD33 P33 l=0.300u w=5.000u
M118 NET_94 NET_90 NET_3553 VDD33 P33 l=0.300u w=5.000u
M119 NET_94 NET_90 NET_3553 VDD33 P33 l=0.300u w=5.000u
M120 NET_3553 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M121 VDD33 NET_44 NET_3553 VDD33 P33 l=0.300u w=5.000u
M122 NET_3553 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M123 PAD NET_60 NET_5988 NET_1362 P33 l=0.300u w=30.000u
M124 VDD33 NET_3512 NET_5988 NET_1362 P33 l=0.300u w=30.000u
M125 VDD33 NET_3512 NET_5986 NET_1362 P33 l=0.300u w=30.000u
M126 NET_5986 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M127 PAD NET_60 NET_5993 NET_1362 P33 l=0.300u w=30.000u
M128 VDD33 NET_3512 NET_5993 NET_1362 P33 l=0.300u w=30.000u
M129 VDD33 NET_3512 NET_5991 NET_1362 P33 l=0.300u w=30.000u
M130 NET_5991 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M131 PAD NET_60 NET_5984 NET_1362 P33 l=0.300u w=30.000u
M132 PAD NET_60 NET_5989 NET_1362 P33 l=0.300u w=30.000u
M133 NET_87 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M134 NET_87 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M135 NET_5978 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M136 NET_5978 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M137 PAD NET_60 NET_5976 NET_1362 P33 l=0.300u w=30.000u
M138 NET_5983 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M139 NET_5983 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M140 PAD NET_60 NET_5981 NET_1362 P33 l=0.300u w=30.000u
M141 NET_5984 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M142 NET_5989 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M143 VDD33 NET_10 NET_87 VDD33 P33 l=0.300u w=5.000u
M144 VDD33 NET_3512 NET_5974 NET_1362 P33 l=0.300u w=30.000u
M145 NET_5974 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M146 VDD33 NET_3512 NET_5979 NET_1362 P33 l=0.300u w=30.000u
M147 NET_5979 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3512 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_10 NET_85 VDD33 P33 l=0.300u w=5.000u
M150 NET_5964 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M151 NET_5964 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M152 NET_5969 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M153 NET_5969 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M154 NET_10 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_59 NET_57 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_57 NET_59 VDD33 P33 l=0.300u w=5.000u
M157 VDD33 NET_3512 NET_5962 NET_1362 P33 l=0.300u w=30.000u
M158 NET_5962 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M159 PAD NET_60 NET_5960 NET_1362 P33 l=0.300u w=30.000u
M160 VDD33 NET_3512 NET_5967 NET_1362 P33 l=0.300u w=30.000u
M161 NET_5967 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M162 PAD NET_60 NET_5965 NET_1362 P33 l=0.300u w=30.000u
M163 NET_5951 NET_45 VDD33 NET_1362 P33 l=0.300u w=30.000u
M164 NET_5955 NET_45 VDD33 NET_1362 P33 l=0.300u w=30.000u
M165 NET_5960 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M166 NET_5965 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M167 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_48 NET_45 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_48 NET_49 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_49 NET_48 VDD33 P33 l=0.300u w=5.000u
M171 PAD NET_60 NET_5949 NET_1362 P33 l=0.300u w=30.000u
M172 NET_5949 NET_45 VDD33 NET_1362 P33 l=0.300u w=30.000u
M173 PAD NET_60 NET_5953 NET_1362 P33 l=0.300u w=30.000u
M174 NET_5953 NET_45 VDD33 NET_1362 P33 l=0.300u w=30.000u
M175 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M176 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M177 VDD33 PAD NET_1362 NET_1362 P33 l=0.350u w=5.000u
M178 VDD33 NET_44 NET_3553 VDD33 P33 l=0.300u w=5.000u
M179 NET_5976 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M180 NET_5981 NET_3512 VDD33 NET_1362 P33 l=0.300u w=30.000u
M181 NET_5951 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M182 NET_5955 NET_60 PAD NET_1362 P33 l=0.300u w=30.000u
M183 PAD VDD33 NET_1362 NET_1362 P33 l=0.350u w=15.000u
M184 PAD VDD33 NET_60 NET_1362 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PB4

.subckt PB24   PAD OEN I C FP
M1 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M3 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M5 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M8 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M9 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M10 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_51 NET_52 NET_50 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M17 NET_55 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_55 VSS N18 l=0.180u w=2.000u
M19 NET_60 NET_55 VSS VSS N18 l=0.180u w=2.000u
M20 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M21 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M23 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M24 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M25 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M26 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M27 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M28 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M29 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M32 NET_6042 OEN NET_55 VDD P18 l=0.180u w=5.000u
M33 NET_6042 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M35 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M36 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M37 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M38 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M39 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_52 NET_50 VDD P18 l=0.180u w=5.000u
M42 NET_50 NET_52 VDD VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_101 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_101 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M59 VSSD NET_101 NET_25 VSSD N33 l=0.400u w=28.000u
M60 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M62 NET_16 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M63 VSSD NET_101 NET_14 VSSD N33 l=0.400u w=28.000u
M64 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M65 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M66 NET_12 NET_101 VSSD VSSD N33 l=0.400u w=28.000u
M67 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M68 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M69 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M70 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M71 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M72 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M73 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M74 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M75 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M76 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M77 NET_101 NET_10 VSS VSS N33 l=0.350u w=8.000u
M78 NET_101 NET_10 VSS VSS N33 l=0.350u w=8.000u
M79 VSS NET_10 NET_101 VSS N33 l=0.350u w=8.000u
M80 VSS NET_67 NET_64 VSS N33 l=0.350u w=8.000u
M81 VSS NET_67 NET_64 VSS N33 l=0.350u w=8.000u
M82 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M83 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M84 NET_67 NET_50 VSS VSS N33 l=0.350u w=5.330u
M85 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M86 NET_68 NET_46 VSS VSS N33 l=0.350u w=5.330u
M87 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M88 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M89 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M90 VSS NET_52 NET_76 VSS N33 l=0.350u w=7.440u
M91 NET_76 NET_52 VSS VSS N33 l=0.350u w=7.440u
M92 NET_81 NET_3500 NET_79 VSS N33 l=0.350u w=8.000u
M93 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M94 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M95 VSS NET_55 NET_10 VSS N33 l=0.350u w=8.000u
M96 VSS NET_55 NET_10 VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_104 VSS N33 l=0.350u w=8.000u
M98 NET_44 VDD33 NET_104 VSS N33 l=0.350u w=8.000u
M99 NET_104 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M100 VSS NET_104 NET_108 VSS N33 l=0.350u w=8.000u
M101 VSS NET_108 NET_94 VSS N33 l=0.350u w=2.000u
M102 VSS NET_108 NET_94 VSS N33 l=0.350u w=2.000u
M103 NET_6009 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M104 NET_6009 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M105 NET_6011 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M106 NET_6011 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M107 NET_1362 NET_1362 NET_1362 NET_1362 P33 l=1.070u w=5.000u
M108 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M109 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M110 NET_94 NET_108 VDD VDD P33 l=0.300u w=5.000u
M111 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M112 PAD NET_79 NET_6002 NET_1362 P33 l=0.300u w=30.000u
M113 VDD33 NET_64 NET_6002 NET_1362 P33 l=0.300u w=30.000u
M114 VDD33 NET_64 NET_6000 NET_1362 P33 l=0.300u w=30.000u
M115 NET_6000 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M116 PAD NET_79 NET_6007 NET_1362 P33 l=0.300u w=30.000u
M117 VDD33 NET_64 NET_6007 NET_1362 P33 l=0.300u w=30.000u
M118 VDD33 NET_64 NET_6005 NET_1362 P33 l=0.300u w=30.000u
M119 NET_6005 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M120 NET_108 NET_104 NET_3535 VDD33 P33 l=0.300u w=5.000u
M121 NET_108 NET_104 NET_3535 VDD33 P33 l=0.300u w=5.000u
M122 NET_108 NET_104 NET_3535 VDD33 P33 l=0.300u w=5.000u
M123 NET_108 NET_104 NET_3535 VDD33 P33 l=0.300u w=5.000u
M124 NET_3535 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M125 VDD33 NET_44 NET_3535 VDD33 P33 l=0.300u w=5.000u
M126 NET_3535 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M127 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M128 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M129 NET_94 NET_108 VDD VDD P33 l=0.300u w=5.000u
M130 VDD NET_108 NET_94 VDD P33 l=0.300u w=5.000u
M131 PAD NET_79 NET_5998 NET_1362 P33 l=0.300u w=30.000u
M132 PAD NET_79 NET_6003 NET_1362 P33 l=0.300u w=30.000u
M133 NET_5998 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M134 NET_5992 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M135 NET_5992 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M136 PAD NET_79 NET_5990 NET_1362 P33 l=0.300u w=30.000u
M137 NET_6003 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M138 NET_5997 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M139 NET_5997 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M140 PAD NET_79 NET_5995 NET_1362 P33 l=0.300u w=30.000u
M141 NET_101 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M142 NET_101 NET_10 VDD33 VDD33 P33 l=0.300u w=5.000u
M143 VDD33 NET_64 NET_5988 NET_1362 P33 l=0.300u w=30.000u
M144 NET_5988 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M145 VDD33 NET_64 NET_5993 NET_1362 P33 l=0.300u w=30.000u
M146 NET_5993 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M147 VDD33 NET_10 NET_101 VDD33 P33 l=0.300u w=5.000u
M148 NET_5978 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M149 NET_5978 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M150 NET_5983 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M151 NET_5983 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M152 VDD33 VSS NET_3500 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_10 NET_99 VDD33 P33 l=0.300u w=5.000u
M154 NET_10 NET_99 VDD33 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_64 NET_5976 NET_1362 P33 l=0.300u w=30.000u
M156 NET_5976 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M157 PAD NET_79 NET_5974 NET_1362 P33 l=0.300u w=30.000u
M158 VDD33 NET_64 NET_5981 NET_1362 P33 l=0.300u w=30.000u
M159 NET_5981 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M160 PAD NET_79 NET_5979 NET_1362 P33 l=0.300u w=30.000u
M161 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M162 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M163 NET_5974 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M164 NET_5965 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M165 NET_5979 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M166 NET_5969 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M167 PAD NET_79 NET_5963 NET_1362 P33 l=0.300u w=30.000u
M168 NET_5963 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M169 PAD NET_79 NET_5967 NET_1362 P33 l=0.300u w=30.000u
M170 NET_5967 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M171 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M172 NET_1362 PAD VDD33 NET_1362 P33 l=0.350u w=5.000u
M173 VDD33 PAD NET_1362 NET_1362 P33 l=0.350u w=5.000u
M174 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M175 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M176 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M177 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M178 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M179 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M180 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M181 VDD33 NET_44 NET_3535 VDD33 P33 l=0.300u w=5.000u
M182 NET_5990 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M183 NET_5995 NET_64 VDD33 NET_1362 P33 l=0.300u w=30.000u
M184 NET_5965 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M185 NET_5969 NET_79 PAD NET_1362 P33 l=0.300u w=30.000u
M186 PAD VDD33 NET_79 NET_1362 P33 l=0.350u w=10.000u
M187 PAD VDD33 NET_1362 NET_1362 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PB24

.subckt PB2   PAD OEN I C FP
M1 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M3 C NET_102 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M5 C NET_102 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_102 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_105 NET_102 VSS N18 l=0.180u w=2.000u
M8 VSS NET_105 NET_102 VSS N18 l=0.180u w=2.000u
M9 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M10 VSS NET_70 NET_66 VSS N18 l=0.180u w=4.000u
M11 NET_71 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_71 NET_72 NET_70 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_72 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_75 VSS N18 l=0.180u w=2.000u
M17 NET_75 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_75 VSS N18 l=0.180u w=2.000u
M19 VSS NET_75 NET_45 VSS N18 l=0.180u w=2.000u
M20 VSS NET_75 NET_45 VSS N18 l=0.180u w=2.000u
M21 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_105 NET_102 VDD P18 l=0.180u w=5.000u
M23 VDD NET_105 NET_102 VDD P18 l=0.180u w=5.000u
M24 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M25 C NET_102 VDD VDD P18 l=0.180u w=5.000u
M26 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M27 C NET_102 VDD VDD P18 l=0.180u w=5.000u
M28 VDD NET_102 C VDD P18 l=0.180u w=5.000u
M29 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M30 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M32 VDD OEN NET_72 VDD P18 l=0.180u w=5.000u
M33 NET_6015 OEN NET_75 VDD P18 l=0.180u w=5.000u
M34 NET_6015 I VDD VDD P18 l=0.180u w=5.000u
M35 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M36 VDD NET_75 NET_45 VDD P18 l=0.180u w=5.000u
M37 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M38 VDD NET_70 NET_66 VDD P18 l=0.180u w=5.000u
M39 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M40 NET_70 I VDD VDD P18 l=0.180u w=5.000u
M41 VDD NET_72 NET_70 VDD P18 l=0.180u w=5.000u
M42 NET_70 NET_72 VDD VDD P18 l=0.180u w=5.000u
M43 NET_41 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M44 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M45 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M46 NET_31 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M47 VSSD NET_24 NET_29 VSSD N33 l=0.400u w=28.000u
M48 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M49 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M50 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M51 NET_43 NET_86 VSSD VSSD N33 l=0.400u w=28.000u
M52 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M53 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M54 NET_38 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M55 VSSD NET_24 NET_36 VSSD N33 l=0.400u w=28.000u
M56 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M57 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M58 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M59 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M60 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M61 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M62 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M63 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M64 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M65 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M66 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M67 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M68 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M69 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M70 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M71 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M72 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M73 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M74 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M75 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M76 NET_85 NET_45 VSS VSS N33 l=0.350u w=8.000u
M77 VSS NET_46 NET_86 VSS N33 l=0.350u w=4.000u
M78 VSS NET_46 NET_86 VSS N33 l=0.350u w=4.000u
M79 VSS NET_50 NET_47 VSS N33 l=0.350u w=4.000u
M80 VSS NET_50 NET_47 VSS N33 l=0.350u w=4.000u
M81 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M82 VSS NET_70 NET_50 VSS N33 l=0.350u w=5.330u
M83 NET_50 NET_70 VSS VSS N33 l=0.350u w=5.330u
M84 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M85 NET_51 NET_66 VSS VSS N33 l=0.350u w=5.330u
M86 VSS NET_66 NET_51 VSS N33 l=0.350u w=5.330u
M87 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M88 NET_61 OEN VSS VSS N33 l=0.350u w=7.440u
M89 VSS NET_72 NET_59 VSS N33 l=0.350u w=7.440u
M90 NET_59 NET_72 VSS VSS N33 l=0.350u w=7.440u
M91 NET_64 NET_3498 NET_62 VSS N33 l=0.350u w=8.000u
M92 NET_64 NET_61 VSS VSS N33 l=0.350u w=8.000u
M93 NET_85 NET_45 VSS VSS N33 l=0.350u w=8.000u
M94 NET_46 NET_75 VSS VSS N33 l=0.350u w=8.000u
M95 NET_46 NET_75 VSS VSS N33 l=0.350u w=8.000u
M96 NET_44 VDD33 NET_89 VSS N33 l=0.350u w=8.000u
M97 NET_44 VDD33 NET_89 VSS N33 l=0.350u w=8.000u
M98 NET_89 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M99 VSS NET_89 NET_93 VSS N33 l=0.350u w=8.000u
M100 VSS NET_93 NET_105 VSS N33 l=0.350u w=2.000u
M101 VSS NET_93 NET_105 VSS N33 l=0.350u w=2.000u
M102 NET_5984 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M103 NET_5984 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M104 NET_5986 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M105 NET_5986 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M106 NET_1361 NET_1361 NET_1361 NET_1361 P33 l=1.070u w=5.000u
M107 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M108 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M109 NET_105 NET_93 VDD VDD P33 l=0.300u w=5.000u
M110 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M111 NET_93 NET_89 NET_3555 VDD33 P33 l=0.300u w=5.000u
M112 NET_93 NET_89 NET_3555 VDD33 P33 l=0.300u w=5.000u
M113 NET_93 NET_89 NET_3555 VDD33 P33 l=0.300u w=5.000u
M114 NET_93 NET_89 NET_3555 VDD33 P33 l=0.300u w=5.000u
M115 NET_3555 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M116 VDD33 NET_44 NET_3555 VDD33 P33 l=0.300u w=5.000u
M117 NET_3555 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M118 PAD NET_62 NET_5977 NET_1361 P33 l=0.300u w=30.000u
M119 VDD33 NET_3498 NET_5977 NET_1361 P33 l=0.300u w=30.000u
M120 VDD33 NET_3498 NET_5975 NET_1361 P33 l=0.300u w=30.000u
M121 NET_5975 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M122 PAD NET_62 NET_5982 NET_1361 P33 l=0.300u w=30.000u
M123 VDD33 NET_3498 NET_5982 NET_1361 P33 l=0.300u w=30.000u
M124 VDD33 NET_3498 NET_5980 NET_1361 P33 l=0.300u w=30.000u
M125 NET_5980 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M126 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M127 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M128 NET_105 NET_93 VDD VDD P33 l=0.300u w=5.000u
M129 VDD NET_93 NET_105 VDD P33 l=0.300u w=5.000u
M130 PAD NET_62 NET_5973 NET_1361 P33 l=0.300u w=30.000u
M131 PAD NET_62 NET_5978 NET_1361 P33 l=0.300u w=30.000u
M132 VDD33 NET_46 NET_86 VDD33 P33 l=0.300u w=5.000u
M133 NET_5967 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M134 NET_5967 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M135 PAD NET_62 NET_5965 NET_1361 P33 l=0.300u w=30.000u
M136 NET_5972 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M137 NET_5972 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M138 PAD NET_62 NET_5970 NET_1361 P33 l=0.300u w=30.000u
M139 NET_5973 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M140 NET_5978 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M141 VDD33 NET_3498 NET_5963 NET_1361 P33 l=0.300u w=30.000u
M142 NET_5963 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M143 VDD33 NET_3498 NET_5968 NET_1361 P33 l=0.300u w=30.000u
M144 NET_5968 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M145 VDD33 VSS NET_3498 VDD33 P33 l=0.300u w=5.000u
M146 VDD33 NET_46 NET_85 VDD33 P33 l=0.300u w=5.000u
M147 NET_5953 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M148 NET_5953 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M149 NET_5958 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M150 NET_5958 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M151 NET_46 NET_85 VDD33 VDD33 P33 l=0.300u w=5.000u
M152 VDD33 NET_61 NET_59 VDD33 P33 l=0.300u w=5.000u
M153 VDD33 NET_59 NET_61 VDD33 P33 l=0.300u w=5.000u
M154 VDD33 NET_3498 NET_5951 NET_1361 P33 l=0.300u w=30.000u
M155 NET_5951 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M156 PAD NET_62 NET_5949 NET_1361 P33 l=0.300u w=30.000u
M157 VDD33 NET_3498 NET_5956 NET_1361 P33 l=0.300u w=30.000u
M158 NET_5956 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M159 PAD NET_62 NET_5954 NET_1361 P33 l=0.300u w=30.000u
M160 NET_5940 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M161 NET_5944 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M162 NET_5949 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M163 NET_5954 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M164 VDD33 NET_50 NET_51 VDD33 P33 l=0.300u w=5.000u
M165 VDD33 NET_51 NET_50 VDD33 P33 l=0.300u w=5.000u
M166 NET_47 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M167 NET_47 NET_50 VDD33 VDD33 P33 l=0.300u w=5.000u
M168 VDD33 NET_50 NET_47 VDD33 P33 l=0.300u w=5.000u
M169 PAD NET_62 NET_5938 NET_1361 P33 l=0.300u w=30.000u
M170 NET_5938 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M171 PAD NET_62 NET_5942 NET_1361 P33 l=0.300u w=30.000u
M172 NET_5942 NET_47 VDD33 NET_1361 P33 l=0.300u w=30.000u
M173 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M174 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M175 VDD33 PAD NET_1361 NET_1361 P33 l=0.350u w=5.000u
M176 VDD33 NET_44 NET_3555 VDD33 P33 l=0.300u w=5.000u
M177 NET_5965 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M178 NET_5970 NET_3498 VDD33 NET_1361 P33 l=0.300u w=30.000u
M179 NET_5940 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M180 NET_5944 NET_62 PAD NET_1361 P33 l=0.300u w=30.000u
M181 PAD VDD33 NET_1361 NET_1361 P33 l=0.350u w=15.000u
M182 PAD VDD33 NET_62 NET_1361 P33 l=0.350u w=10.000u
R1 PAD NET_44 300.135
.ends PB2

.subckt PB16   PAD OEN I C FP
M1 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M3 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M5 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M8 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M9 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M10 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_51 NET_52 NET_50 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M17 NET_55 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_55 VSS N18 l=0.180u w=2.000u
M19 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M20 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M21 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M23 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M24 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M25 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M26 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M27 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M28 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M29 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M32 NET_6041 OEN NET_55 VDD P18 l=0.180u w=5.000u
M33 NET_6041 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M35 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M36 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M37 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M38 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_52 NET_50 VDD P18 l=0.180u w=5.000u
M41 NET_50 NET_52 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M43 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M44 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M45 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M46 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M47 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M48 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M49 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M50 NET_67 NET_50 VSS VSS N33 l=0.350u w=5.330u
M51 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M52 NET_68 NET_46 VSS VSS N33 l=0.350u w=5.330u
M53 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M54 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M55 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M56 VSS NET_52 NET_76 VSS N33 l=0.350u w=7.440u
M57 NET_76 NET_52 VSS VSS N33 l=0.350u w=7.440u
M58 NET_81 NET_3502 NET_79 VSS N33 l=0.350u w=8.000u
M59 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M60 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M61 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M62 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M63 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M64 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M65 NET_103 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M66 VSS NET_103 NET_107 VSS N33 l=0.350u w=8.000u
M67 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M68 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M69 NET_41 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M70 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_31 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_100 NET_29 VSSD N33 l=0.400u w=28.000u
M74 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M75 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M76 NET_27 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M77 NET_43 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M78 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M79 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M80 NET_38 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M81 VSSD NET_100 NET_36 VSSD N33 l=0.400u w=28.000u
M82 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M83 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M84 NET_34 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M85 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M86 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M87 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M88 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M89 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M90 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M91 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M92 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M93 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M94 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M95 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M96 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M97 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M98 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M99 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M100 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M101 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M102 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M103 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M104 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M105 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M106 NET_6010 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M107 NET_6010 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M108 NET_6012 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M109 NET_6012 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M110 NET_1361 NET_1361 NET_1361 NET_1361 P33 l=1.070u w=5.000u
M111 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M112 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M113 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M114 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M115 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M116 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M117 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M118 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M119 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M120 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M121 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M122 PAD NET_79 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M123 VDD33 NET_3502 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M124 VDD33 NET_3502 NET_6001 NET_1361 P33 l=0.300u w=30.000u
M125 NET_6001 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M126 PAD NET_79 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M127 VDD33 NET_3502 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M128 VDD33 NET_3502 NET_6006 NET_1361 P33 l=0.300u w=30.000u
M129 NET_6006 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M130 PAD NET_79 NET_5999 NET_1361 P33 l=0.300u w=30.000u
M131 PAD NET_79 NET_6004 NET_1361 P33 l=0.300u w=30.000u
M132 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M133 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M134 NET_5993 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M135 NET_5993 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M136 PAD NET_79 NET_5991 NET_1361 P33 l=0.300u w=30.000u
M137 NET_5998 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M138 NET_5998 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M139 PAD NET_79 NET_5996 NET_1361 P33 l=0.300u w=30.000u
M140 NET_5999 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M141 NET_6004 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M142 VDD33 NET_82 NET_100 VDD33 P33 l=0.300u w=5.000u
M143 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M144 VDD33 NET_64 NET_5989 NET_1361 P33 l=0.300u w=30.000u
M145 NET_5989 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M146 VDD33 NET_64 NET_5994 NET_1361 P33 l=0.300u w=30.000u
M147 NET_5994 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3502 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_82 NET_99 VDD33 P33 l=0.300u w=5.000u
M150 NET_5979 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M151 NET_5979 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M152 NET_5984 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M153 NET_5984 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M154 NET_82 NET_99 VDD33 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M157 VDD33 NET_64 NET_5977 NET_1361 P33 l=0.300u w=30.000u
M158 NET_5977 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M159 PAD NET_79 NET_5975 NET_1361 P33 l=0.300u w=30.000u
M160 VDD33 NET_64 NET_5982 NET_1361 P33 l=0.300u w=30.000u
M161 NET_5982 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M162 PAD NET_79 NET_5980 NET_1361 P33 l=0.300u w=30.000u
M163 NET_5966 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M164 NET_5970 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M165 NET_5975 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M166 NET_5980 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M167 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M168 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M172 PAD NET_79 NET_5964 NET_1361 P33 l=0.300u w=30.000u
M173 NET_5964 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M174 PAD NET_79 NET_5968 NET_1361 P33 l=0.300u w=30.000u
M175 NET_5968 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M176 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M177 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M178 VDD33 PAD NET_1361 NET_1361 P33 l=0.350u w=5.000u
M179 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M180 NET_5991 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M181 NET_5996 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M182 NET_5966 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M183 NET_5970 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_79 NET_1361 P33 l=0.350u w=10.000u
M185 PAD VDD33 NET_1361 NET_1361 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PB16

.subckt PB12   PAD OEN I C FP
M1 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M2 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M3 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M4 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M5 C NET_91 VSS VSS N18 l=0.180u w=2.000u
M6 VSS NET_91 C VSS N18 l=0.180u w=2.000u
M7 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M8 VSS NET_94 NET_91 VSS N18 l=0.180u w=2.000u
M9 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M10 VSS NET_50 NET_46 VSS N18 l=0.180u w=4.000u
M11 NET_51 I VSS VSS N18 l=0.180u w=4.000u
M12 NET_51 NET_52 NET_50 VSS N18 l=0.180u w=4.000u
M13 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M14 VSS OEN NET_52 VSS N18 l=0.180u w=2.000u
M15 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M16 VSS OEN NET_55 VSS N18 l=0.180u w=2.000u
M17 NET_55 I VSS VSS N18 l=0.180u w=2.000u
M18 VSS I NET_55 VSS N18 l=0.180u w=2.000u
M19 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M20 VSS NET_55 NET_60 VSS N18 l=0.180u w=2.000u
M21 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M22 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M23 VDD NET_94 NET_91 VDD P18 l=0.180u w=5.000u
M24 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M25 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M26 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M27 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M28 C NET_91 VDD VDD P18 l=0.180u w=5.000u
M29 VDD NET_91 C VDD P18 l=0.180u w=5.000u
M30 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M31 VDD OEN NET_52 VDD P18 l=0.180u w=5.000u
M32 NET_6041 OEN NET_55 VDD P18 l=0.180u w=5.000u
M33 NET_6041 I VDD VDD P18 l=0.180u w=5.000u
M34 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M35 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M36 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M37 VDD NET_50 NET_46 VDD P18 l=0.180u w=5.000u
M38 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M39 NET_50 I VDD VDD P18 l=0.180u w=5.000u
M40 VDD NET_52 NET_50 VDD P18 l=0.180u w=5.000u
M41 NET_50 NET_52 VDD VDD P18 l=0.180u w=5.000u
M42 VDD NET_55 NET_60 VDD P18 l=0.180u w=5.000u
M43 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M44 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M45 VSS NET_82 NET_100 VSS N33 l=0.350u w=8.000u
M46 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M47 VSS NET_67 NET_64 VSS N33 l=0.350u w=10.000u
M48 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M49 VSS NET_50 NET_67 VSS N33 l=0.350u w=5.330u
M50 NET_67 NET_50 VSS VSS N33 l=0.350u w=5.330u
M51 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M52 NET_68 NET_46 VSS VSS N33 l=0.350u w=5.330u
M53 VSS NET_46 NET_68 VSS N33 l=0.350u w=5.330u
M54 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M55 NET_78 OEN VSS VSS N33 l=0.350u w=7.440u
M56 VSS NET_52 NET_76 VSS N33 l=0.350u w=7.440u
M57 NET_76 NET_52 VSS VSS N33 l=0.350u w=7.440u
M58 NET_81 NET_3502 NET_79 VSS N33 l=0.350u w=8.000u
M59 NET_81 NET_78 VSS VSS N33 l=0.350u w=8.000u
M60 NET_99 NET_60 VSS VSS N33 l=0.350u w=8.000u
M61 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M62 NET_82 NET_55 VSS VSS N33 l=0.350u w=8.000u
M63 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M64 NET_44 VDD33 NET_103 VSS N33 l=0.350u w=8.000u
M65 NET_103 VDD33 NET_44 VSS N33 l=0.350u w=8.000u
M66 VSS NET_103 NET_107 VSS N33 l=0.350u w=8.000u
M67 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M68 VSS NET_107 NET_94 VSS N33 l=0.350u w=2.000u
M69 NET_41 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M70 NET_41 FP PAD VSSD N33 l=0.400u w=28.000u
M71 NET_31 FP PAD VSSD N33 l=0.400u w=28.000u
M72 NET_31 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M73 VSSD NET_100 NET_29 VSSD N33 l=0.400u w=28.000u
M74 NET_29 FP PAD VSSD N33 l=0.400u w=28.000u
M75 PAD FP NET_27 VSSD N33 l=0.400u w=28.000u
M76 NET_27 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M77 NET_43 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M78 NET_43 FP PAD VSSD N33 l=0.400u w=28.000u
M79 NET_38 FP PAD VSSD N33 l=0.400u w=28.000u
M80 NET_38 NET_100 VSSD VSSD N33 l=0.400u w=28.000u
M81 VSSD NET_100 NET_36 VSSD N33 l=0.400u w=28.000u
M82 NET_36 FP PAD VSSD N33 l=0.400u w=28.000u
M83 PAD FP NET_34 VSSD N33 l=0.400u w=28.000u
M84 NET_34 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M85 NET_25 FP PAD VSSD N33 l=0.400u w=28.000u
M86 NET_16 FP PAD VSSD N33 l=0.400u w=28.000u
M87 NET_16 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M88 VSSD NET_24 NET_14 VSSD N33 l=0.400u w=28.000u
M89 NET_14 FP PAD VSSD N33 l=0.400u w=28.000u
M90 PAD FP NET_12 VSSD N33 l=0.400u w=28.000u
M91 NET_12 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M92 NET_32 FP PAD VSSD N33 l=0.400u w=28.000u
M93 NET_22 FP PAD VSSD N33 l=0.400u w=28.000u
M94 NET_22 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M95 VSSD NET_24 NET_20 VSSD N33 l=0.400u w=28.000u
M96 NET_20 FP PAD VSSD N33 l=0.400u w=28.000u
M97 PAD FP NET_18 VSSD N33 l=0.400u w=28.000u
M98 NET_18 NET_24 VSSD VSSD N33 l=0.400u w=28.000u
M99 NET_24 VDD33 VSSD VSSD N33 l=0.350u w=4.000u
M100 VSSD NET_24 NET_25 VSSD N33 l=0.400u w=28.000u
M101 VSSD NET_24 NET_32 VSSD N33 l=0.400u w=28.000u
M102 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M103 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M104 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M105 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M106 NET_6010 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M107 NET_6010 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M108 NET_6012 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M109 NET_6012 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M110 NET_1361 NET_1361 NET_1361 NET_1361 P33 l=1.070u w=5.000u
M111 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M112 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M113 NET_94 NET_107 VDD VDD P33 l=0.300u w=5.000u
M114 VDD NET_107 NET_94 VDD P33 l=0.300u w=5.000u
M115 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M116 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M117 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M118 NET_107 NET_103 NET_3544 VDD33 P33 l=0.300u w=5.000u
M119 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M120 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M121 NET_3544 NET_44 VDD33 VDD33 P33 l=0.300u w=5.000u
M122 PAD NET_79 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M123 VDD33 NET_3502 NET_6003 NET_1361 P33 l=0.300u w=30.000u
M124 VDD33 NET_3502 NET_6001 NET_1361 P33 l=0.300u w=30.000u
M125 NET_6001 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M126 PAD NET_79 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M127 VDD33 NET_3502 NET_6008 NET_1361 P33 l=0.300u w=30.000u
M128 VDD33 NET_3502 NET_6006 NET_1361 P33 l=0.300u w=30.000u
M129 NET_6006 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M130 PAD NET_79 NET_5999 NET_1361 P33 l=0.300u w=30.000u
M131 PAD NET_79 NET_6004 NET_1361 P33 l=0.300u w=30.000u
M132 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M133 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M134 NET_5993 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M135 NET_5993 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M136 PAD NET_79 NET_5991 NET_1361 P33 l=0.300u w=30.000u
M137 NET_5998 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M138 NET_5998 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M139 PAD NET_79 NET_5996 NET_1361 P33 l=0.300u w=30.000u
M140 NET_5999 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M141 NET_6004 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M142 VDD33 NET_82 NET_100 VDD33 P33 l=0.300u w=5.000u
M143 NET_100 NET_82 VDD33 VDD33 P33 l=0.300u w=5.000u
M144 VDD33 NET_64 NET_5989 NET_1361 P33 l=0.300u w=30.000u
M145 NET_5989 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M146 VDD33 NET_64 NET_5994 NET_1361 P33 l=0.300u w=30.000u
M147 NET_5994 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M148 VDD33 VSS NET_3502 VDD33 P33 l=0.300u w=5.000u
M149 VDD33 NET_82 NET_99 VDD33 P33 l=0.300u w=5.000u
M150 NET_5979 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M151 NET_5979 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M152 NET_5984 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M153 NET_5984 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M154 NET_82 NET_99 VDD33 VDD33 P33 l=0.300u w=5.000u
M155 VDD33 NET_78 NET_76 VDD33 P33 l=0.300u w=5.000u
M156 VDD33 NET_76 NET_78 VDD33 P33 l=0.300u w=5.000u
M157 VDD33 NET_64 NET_5977 NET_1361 P33 l=0.300u w=30.000u
M158 NET_5977 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M159 PAD NET_79 NET_5975 NET_1361 P33 l=0.300u w=30.000u
M160 VDD33 NET_64 NET_5982 NET_1361 P33 l=0.300u w=30.000u
M161 NET_5982 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M162 PAD NET_79 NET_5980 NET_1361 P33 l=0.300u w=30.000u
M163 NET_5966 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M164 NET_5970 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M165 NET_5975 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M166 NET_5980 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M167 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M168 NET_64 NET_67 VDD33 VDD33 P33 l=0.300u w=5.000u
M169 VDD33 NET_67 NET_64 VDD33 P33 l=0.300u w=5.000u
M170 VDD33 NET_67 NET_68 VDD33 P33 l=0.300u w=5.000u
M171 VDD33 NET_68 NET_67 VDD33 P33 l=0.300u w=5.000u
M172 PAD NET_79 NET_5964 NET_1361 P33 l=0.300u w=30.000u
M173 NET_5964 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M174 PAD NET_79 NET_5968 NET_1361 P33 l=0.300u w=30.000u
M175 NET_5968 NET_64 VDD33 NET_1361 P33 l=0.300u w=30.000u
M176 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M177 NET_1361 PAD VDD33 NET_1361 P33 l=0.350u w=5.000u
M178 VDD33 PAD NET_1361 NET_1361 P33 l=0.350u w=5.000u
M179 VDD33 NET_44 NET_3544 VDD33 P33 l=0.300u w=5.000u
M180 NET_5991 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M181 NET_5996 NET_3502 VDD33 NET_1361 P33 l=0.300u w=30.000u
M182 NET_5966 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M183 NET_5970 NET_79 PAD NET_1361 P33 l=0.300u w=30.000u
M184 PAD VDD33 NET_79 NET_1361 P33 l=0.350u w=10.000u
M185 PAD VDD33 NET_1361 NET_1361 P33 l=0.350u w=15.000u
R1 PAD NET_44 300.135
.ends PB12

.subckt PVDD1CAP SVDD1CAP
M1 SVDD1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M2 SVDD1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M3 SAVSS SAVSS SVDD1CAP SAVSS N18 l=0.180u w=28.000u
M4 SVDD1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M5 SAVSS SAVSS SVDD1CAP SAVSS N18 l=0.180u w=28.000u
M6 SVDD1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M7 SAVSS SAVSS SVDD1CAP SAVSS N18 l=0.180u w=28.000u
M8 SVDD1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M9 SVDD1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M10 SVDD1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M11 SAVSS SAVSS SVDD1CAP SAVSS N18 l=0.180u w=28.000u
M12 SVDD1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M13 SAVSS SAVSS SVDD1CAP SAVSS N18 l=0.180u w=28.000u
M14 SVDD1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M15 SAVSS SAVSS SVDD1CAP SAVSS N18 l=0.180u w=28.000u
M16 SVDD1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M17 SVDD1CAP SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M18 SVDD1CAP SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M19 SAVDD SAVDD SVDD1CAP SAVDD P18 l=0.300u w=30.000u
M20 SVDD1CAP SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M21 SAVDD SAVDD SVDD1CAP SAVDD P18 l=0.300u w=30.000u
M22 SVDD1CAP SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M23 SAVDD SAVDD SVDD1CAP SAVDD P18 l=0.300u w=30.000u
M24 SVDD1CAP SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M25 SVDD1CAP SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M26 SVDD1CAP SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M27 SAVDD SAVDD SVDD1CAP SAVDD P18 l=0.300u w=30.000u
M28 SVDD1CAP SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M29 SAVDD SAVDD SVDD1CAP SAVDD P18 l=0.300u w=30.000u
M30 SVDD1CAP SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M31 SAVDD SAVDD SVDD1CAP SAVDD P18 l=0.300u w=30.000u
M32 SVDD1CAP SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
.ends PVDD1CAP

.subckt PVDD1CAP1 SVDD1CAP1
M1 SVDD1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M2 SVDD1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M3 SAVSSD SAVSSD SVDD1CAP1 SAVSSD N18 l=0.180u w=28.000u
M4 SVDD1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M5 SAVSSD SAVSSD SVDD1CAP1 SAVSSD N18 l=0.180u w=28.000u
M6 SVDD1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M7 SAVSSD SAVSSD SVDD1CAP1 SAVSSD N18 l=0.180u w=28.000u
M8 SVDD1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M9 SVDD1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M10 SVDD1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M11 SAVSSD SAVSSD SVDD1CAP1 SAVSSD N18 l=0.180u w=28.000u
M12 SVDD1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M13 SAVSSD SAVSSD SVDD1CAP1 SAVSSD N18 l=0.180u w=28.000u
M14 SVDD1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M15 SAVSSD SAVSSD SVDD1CAP1 SAVSSD N18 l=0.180u w=28.000u
M16 SVDD1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M17 SVDD1CAP1 SAVDD33 SAVDD33 SAVDD33 P18 l=0.300u w=30.000u
M18 SVDD1CAP1 SAVDD33 SAVDD33 SAVDD33 P18 l=0.300u w=30.000u
M19 SAVDD33 SAVDD33 SVDD1CAP1 SAVDD33 P18 l=0.300u w=30.000u
M20 SVDD1CAP1 SAVDD33 SAVDD33 SAVDD33 P18 l=0.300u w=30.000u
M21 SAVDD33 SAVDD33 SVDD1CAP1 SAVDD33 P18 l=0.300u w=30.000u
M22 SVDD1CAP1 SAVDD33 SAVDD33 SAVDD33 P18 l=0.300u w=30.000u
M23 SAVDD33 SAVDD33 SVDD1CAP1 SAVDD33 P18 l=0.300u w=30.000u
M24 SVDD1CAP1 SAVDD33 SAVDD33 SAVDD33 P18 l=0.300u w=30.000u
M25 SVDD1CAP1 SAVDD33 SAVDD33 SAVDD33 P18 l=0.300u w=30.000u
M26 SVDD1CAP1 SAVDD33 SAVDD33 SAVDD33 P18 l=0.300u w=30.000u
M27 SAVDD33 SAVDD33 SVDD1CAP1 SAVDD33 P18 l=0.300u w=30.000u
M28 SVDD1CAP1 SAVDD33 SAVDD33 SAVDD33 P18 l=0.300u w=30.000u
M29 SAVDD33 SAVDD33 SVDD1CAP1 SAVDD33 P18 l=0.300u w=30.000u
M30 SVDD1CAP1 SAVDD33 SAVDD33 SAVDD33 P18 l=0.300u w=30.000u
M31 SAVDD33 SAVDD33 SVDD1CAP1 SAVDD33 P18 l=0.300u w=30.000u
M32 SVDD1CAP1 SAVDD33 SAVDD33 SAVDD33 P18 l=0.300u w=30.000u
.ends PVDD1CAP1

.subckt PVSS1CAP SVSS1CAP
M1 SVSS1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M2 SVSS1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M3 SAVSS SAVSS SVSS1CAP SAVSS N18 l=0.180u w=28.000u
M4 SVSS1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M5 SAVSS SAVSS SVSS1CAP SAVSS N18 l=0.180u w=28.000u
M6 SVSS1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M7 SAVSS SAVSS SVSS1CAP SAVSS N18 l=0.180u w=28.000u
M8 SVSS1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M9 SVSS1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M10 SVSS1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M11 SAVSS SAVSS SVSS1CAP SAVSS N18 l=0.180u w=28.000u
M12 SVSS1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M13 SAVSS SAVSS SVSS1CAP SAVSS N18 l=0.180u w=28.000u
M14 SVSS1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M15 SAVSS SAVSS SVSS1CAP SAVSS N18 l=0.180u w=28.000u
M16 SVSS1CAP SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M17 SVSS1CAP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M18 SVSS1CAP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M19 SAVDD SAVDD SVSS1CAP SAVDD P33 l=0.300u w=30.000u
M20 SVSS1CAP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M21 SAVDD SAVDD SVSS1CAP SAVDD P33 l=0.300u w=30.000u
M22 SVSS1CAP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M23 SAVDD SAVDD SVSS1CAP SAVDD P33 l=0.300u w=30.000u
M24 SVSS1CAP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M25 SVSS1CAP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M26 SVSS1CAP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M27 SAVDD SAVDD SVSS1CAP SAVDD P33 l=0.300u w=30.000u
M28 SVSS1CAP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M29 SAVDD SAVDD SVSS1CAP SAVDD P33 l=0.300u w=30.000u
M30 SVSS1CAP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
M31 SAVDD SAVDD SVSS1CAP SAVDD P33 l=0.300u w=30.000u
M32 SVSS1CAP SAVDD SAVDD SAVDD P33 l=0.300u w=30.000u
.ends PVSS1CAP

.subckt PVSS1CAP1 SVSS1CAP1
M1 SVSS1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M2 SVSS1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M3 SAVSSD SAVSSD SVSS1CAP1 SAVSSD N18 l=0.180u w=28.000u
M4 SVSS1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M5 SAVSSD SAVSSD SVSS1CAP1 SAVSSD N18 l=0.180u w=28.000u
M6 SVSS1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M7 SAVSSD SAVSSD SVSS1CAP1 SAVSSD N18 l=0.180u w=28.000u
M8 SVSS1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M9 SVSS1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M10 SVSS1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M11 SAVSSD SAVSSD SVSS1CAP1 SAVSSD N18 l=0.180u w=28.000u
M12 SVSS1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M13 SAVSSD SAVSSD SVSS1CAP1 SAVSSD N18 l=0.180u w=28.000u
M14 SVSS1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M15 SAVSSD SAVSSD SVSS1CAP1 SAVSSD N18 l=0.180u w=28.000u
M16 SVSS1CAP1 SAVSSD SAVSSD SAVSSD N18 l=0.180u w=28.000u
M17 SVSS1CAP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M18 SVSS1CAP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M19 SAVDD33 SAVDD33 SVSS1CAP1 SAVDD33 P33 l=0.300u w=30.000u
M20 SVSS1CAP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M21 SAVDD33 SAVDD33 SVSS1CAP1 SAVDD33 P33 l=0.300u w=30.000u
M22 SVSS1CAP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M23 SAVDD33 SAVDD33 SVSS1CAP1 SAVDD33 P33 l=0.300u w=30.000u
M24 SVSS1CAP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M25 SVSS1CAP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M26 SVSS1CAP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M27 SAVDD33 SAVDD33 SVSS1CAP1 SAVDD33 P33 l=0.300u w=30.000u
M28 SVSS1CAP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M29 SAVDD33 SAVDD33 SVSS1CAP1 SAVDD33 P33 l=0.300u w=30.000u
M30 SVSS1CAP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
M31 SAVDD33 SAVDD33 SVSS1CAP1 SAVDD33 P33 l=0.300u w=30.000u
M32 SVSS1CAP1 SAVDD33 SAVDD33 SAVDD33 P33 l=0.300u w=30.000u
.ends PVSS1CAP1

.subckt PANA4AP  PAD
M1 NET_54 NET_50 SAVSS SAVSS N33 l=0.350u w=2.500u
M2 NET_54 NET_50 SAVSS SAVSS N33 l=0.350u w=2.500u
M3 SAVSS NET_50 NET_54 SAVSS N33 l=0.350u w=2.500u
M4 NET_54 NET_50 SAVSS SAVSS N33 l=0.350u w=2.500u
M5 SAVSS NET_48 NET_50 SAVSS N33 l=0.350u w=2.500u
M6 NET_50 NET_48 SAVSS SAVSS N33 l=0.350u w=2.500u
M7 SAVSS NET_48 NET_50 SAVSS N33 l=0.350u w=2.500u
M8 NET_50 NET_48 SAVSS SAVSS N33 l=0.350u w=2.500u
M9 SAVSS NET_5198 NET_48 SAVSS N33 l=0.350u w=2.500u
M10 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M11 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M12 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M13 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M14 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M15 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M16 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M17 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M18 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M19 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M20 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M21 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M22 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M23 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M24 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M25 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M26 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M27 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M28 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=28.000u
M29 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=28.000u
M30 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M31 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M32 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M33 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M34 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M35 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M36 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M37 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M38 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M39 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M40 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M41 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M42 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M43 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M44 SAVSS NET_54 SAVDD SAVSS N33 l=0.350u w=35.000u
M45 SAVDD NET_54 SAVSS SAVSS N33 l=0.350u w=35.000u
M46 NET_54 NET_50 SAVDD SAVDD P33 l=0.350u w=2.500u
M47 NET_54 NET_50 SAVDD SAVDD P33 l=0.350u w=2.500u
M48 SAVDD NET_50 NET_54 SAVDD P33 l=0.350u w=2.500u
M49 NET_54 NET_50 SAVDD SAVDD P33 l=0.350u w=2.500u
M50 SAVDD NET_48 NET_50 SAVDD P33 l=0.350u w=2.500u
M51 NET_50 NET_48 SAVDD SAVDD P33 l=0.350u w=2.500u
M52 SAVDD NET_5198 NET_48 SAVDD P33 l=0.350u w=2.500u
M53 NET_48 NET_5198 SAVDD SAVDD P33 l=0.350u w=2.500u
M54 SAVDD NET_5198 NET_48 SAVDD P33 l=0.350u w=2.500u
M55 NET_7502 SAVSS NET_5198 SAVDD P33 l=7.120u w=0.300u
M56 NET_7502 SAVSS NET_7501 SAVDD P33 l=7.120u w=0.300u
M57 SAVDD SAVSS NET_7501 SAVDD P33 l=7.120u w=0.300u
M58 SAVSS NET_5198 SAVSS SAVSS C2 l=4.960u w=19.941u
M59 SAVSS NET_5198 SAVSS SAVSS C2 l=4.960u w=19.941u
DD1 SAVSS PAD NDIO33 area=306.710p pj=78.488u
DD2 PAD SAVDD PDIO33 area=128.999p pj=63.094u
.ends PANA4AP

.subckt PVDD3CAP SAVDD
M1 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M2 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M3 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M4 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M5 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M6 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M7 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M8 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M9 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M10 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M11 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M12 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M13 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M14 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M15 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M16 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M17 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M18 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M19 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M20 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M21 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M22 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M23 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M24 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M25 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M26 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M27 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M28 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M29 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M30 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M31 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M32 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
.ends PVDD3CAP

.subckt PVSS3CAP SAVSS
M1 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M2 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M3 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M4 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M5 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M6 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M7 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M8 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M9 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M10 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M11 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M12 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M13 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M14 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M15 SAVSS SAVSS SAVDD SAVSS N18 l=0.180u w=28.000u
M16 SAVDD SAVSS SAVSS SAVSS N18 l=0.180u w=28.000u
M17 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M18 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M19 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M20 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M21 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M22 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M23 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M24 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M25 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M26 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M27 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M28 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M29 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M30 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
M31 SAVDD SAVDD SAVSS SAVDD P18 l=0.300u w=30.000u
M32 SAVSS SAVDD SAVDD SAVDD P18 l=0.300u w=30.000u
.ends PVSS3CAP

.subckt PVDD1ANP  SVDD1ANP FP
M1 SVDD1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M2 SVDD1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M3 VSSD VSSD SVDD1ANP VSSD N33 l=0.350u w=28.000u
M4 SVDD1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M5 VSSD VSSD SVDD1ANP VSSD N33 l=0.350u w=28.000u
M6 SVDD1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M7 VSSD VSSD SVDD1ANP VSSD N33 l=0.350u w=28.000u
M8 SVDD1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M9 SVDD1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M10 SVDD1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M11 VSSD VSSD SVDD1ANP VSSD N33 l=0.350u w=28.000u
M12 SVDD1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M13 VSSD VSSD SVDD1ANP VSSD N33 l=0.350u w=28.000u
M14 SVDD1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M15 VSSD VSSD SVDD1ANP VSSD N33 l=0.350u w=28.000u
M16 SVDD1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M17 SVDD1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M18 SVDD1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M19 VDD33 VDD33 SVDD1ANP VDD33 P33 l=0.300u w=30.000u
M20 SVDD1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M21 VDD33 VDD33 SVDD1ANP VDD33 P33 l=0.300u w=30.000u
M22 SVDD1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M23 VDD33 VDD33 SVDD1ANP VDD33 P33 l=0.300u w=30.000u
M24 SVDD1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M25 SVDD1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M26 SVDD1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M27 VDD33 VDD33 SVDD1ANP VDD33 P33 l=0.300u w=30.000u
M28 SVDD1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M29 VDD33 VDD33 SVDD1ANP VDD33 P33 l=0.300u w=30.000u
M30 SVDD1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M31 VDD33 VDD33 SVDD1ANP VDD33 P33 l=0.300u w=30.000u
M32 SVDD1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
.ends PVDD1ANP

.subckt PVSS1ANP  SVSS1ANP FP
M1 SVSS1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M2 SVSS1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M3 VSSD VSSD SVSS1ANP VSSD N33 l=0.350u w=28.000u
M4 SVSS1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M5 VSSD VSSD SVSS1ANP VSSD N33 l=0.350u w=28.000u
M6 SVSS1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M7 VSSD VSSD SVSS1ANP VSSD N33 l=0.350u w=28.000u
M8 SVSS1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M9 SVSS1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M10 SVSS1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M11 VSSD VSSD SVSS1ANP VSSD N33 l=0.350u w=28.000u
M12 SVSS1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M13 VSSD VSSD SVSS1ANP VSSD N33 l=0.350u w=28.000u
M14 SVSS1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M15 VSSD VSSD SVSS1ANP VSSD N33 l=0.350u w=28.000u
M16 SVSS1ANP VSSD VSSD VSSD N33 l=0.350u w=28.000u
M17 SVSS1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M18 SVSS1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M19 VDD33 VDD33 SVSS1ANP VDD33 P33 l=0.300u w=30.000u
M20 SVSS1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M21 VDD33 VDD33 SVSS1ANP VDD33 P33 l=0.300u w=30.000u
M22 SVSS1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M23 VDD33 VDD33 SVSS1ANP VDD33 P33 l=0.300u w=30.000u
M24 SVSS1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M25 SVSS1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M26 SVSS1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M27 VDD33 VDD33 SVSS1ANP VDD33 P33 l=0.300u w=30.000u
M28 SVSS1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M29 VDD33 VDD33 SVSS1ANP VDD33 P33 l=0.300u w=30.000u
M30 SVSS1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
M31 VDD33 VDD33 SVSS1ANP VDD33 P33 l=0.300u w=30.000u
M32 SVSS1ANP VDD33 VDD33 VDD33 P33 l=0.300u w=30.000u
.ends PVSS1ANP

.subckt PANA3AP PAD
M1 NET_55 NET_51 SAVSS SAVSS N33 l=0.350u w=2.500u
M2 NET_55 NET_51 SAVSS SAVSS N33 l=0.350u w=2.500u
M3 SAVSS NET_51 NET_55 SAVSS N33 l=0.350u w=2.500u
M4 NET_55 NET_51 SAVSS SAVSS N33 l=0.350u w=2.500u
M5 SAVSS NET_49 NET_51 SAVSS N33 l=0.350u w=2.500u
M6 NET_51 NET_49 SAVSS SAVSS N33 l=0.350u w=2.500u
M7 SAVSS NET_49 NET_51 SAVSS N33 l=0.350u w=2.500u
M8 NET_51 NET_49 SAVSS SAVSS N33 l=0.350u w=2.500u
M9 SAVSS NET_4515 NET_49 SAVSS N33 l=0.350u w=2.500u
M10 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=35.000u
M11 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=35.000u
M12 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=35.000u
M13 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=35.000u
M14 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=35.000u
M15 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=35.000u
M16 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=35.000u
M17 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=35.000u
M18 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=35.000u
M19 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=35.000u
M20 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=35.000u
M21 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=35.000u
M22 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=35.000u
M23 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=35.000u
M24 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=35.000u
M25 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=35.000u
M26 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M27 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M28 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=28.000u
M29 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M30 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=28.000u
M31 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M32 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=28.000u
M33 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M34 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=28.000u
M35 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M36 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=28.000u
M37 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M38 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M39 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M40 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=28.000u
M41 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M42 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=28.000u
M43 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M44 SAVSS NET_55 SAVDD SAVSS N33 l=0.350u w=28.000u
M45 SAVDD NET_55 SAVSS SAVSS N33 l=0.350u w=28.000u
M46 NET_55 NET_51 SAVDD SAVDD P33 l=0.350u w=2.500u
M47 NET_55 NET_51 SAVDD SAVDD P33 l=0.350u w=2.500u
M48 SAVDD NET_51 NET_55 SAVDD P33 l=0.350u w=2.500u
M49 NET_55 NET_51 SAVDD SAVDD P33 l=0.350u w=2.500u
M50 SAVDD NET_49 NET_51 SAVDD P33 l=0.350u w=2.500u
M51 NET_51 NET_49 SAVDD SAVDD P33 l=0.350u w=2.500u
M52 SAVDD NET_4515 NET_49 SAVDD P33 l=0.350u w=2.500u
M53 NET_49 NET_4515 SAVDD SAVDD P33 l=0.350u w=2.500u
M54 SAVDD NET_4515 NET_49 SAVDD P33 l=0.350u w=2.500u
M55 NET_6765 SAVSS NET_4515 SAVDD P33 l=7.120u w=0.300u
M56 NET_6765 SAVSS NET_6764 SAVDD P33 l=7.120u w=0.300u
M57 SAVDD SAVSS NET_6764 SAVDD P33 l=7.120u w=0.300u
M58 SAVSS NET_4515 SAVSS SAVSS C2 l=4.960u w=19.941u
M59 SAVSS NET_4515 SAVSS SAVSS C2 l=4.960u w=19.941u
DD1 SAVSS PAD NDIO33 area=306.710p pj=78.488u
DD2 PAD NET_3029 PDIO33 area=12.324p pj=14.434u
DD3 NET_3029 NET_3327 PDIO33 area=12.324p pj=14.434u
DD4 NET_3327 NET_3582 PDIO33 area=12.324p pj=14.434u
DD5 NET_3582 NET_3819 PDIO33 area=12.324p pj=14.434u
DD6 NET_3819 SAVDD PDIO33 area=12.324p pj=14.434u
.ends PANA3AP
