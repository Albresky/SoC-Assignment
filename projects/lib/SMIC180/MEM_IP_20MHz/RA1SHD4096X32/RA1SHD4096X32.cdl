*
* Copyright 2002 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
*
* Generated by bif2cdl v3.3c
* Version: 2005Q3V1
* Name: High Speed/Density Single-Port SRAM|SMIC 0.18um Logic018 Process
* Comment:
* Configuration:  -instname RA1SHD4096X32 -words 4096 -bits 32 -fre\
* Configuration: quency 20 -ring_width 2 -mux 16 -drive 12 -write_m\
* Configuration: ask on -wp_size 8 -top_layer met6 -power_type ring\
* Configuration: s -horiz met3 -vert met4 -cust_comment "" -left_bu\
* Configuration: s_delim "[" -right_bus_delim "]" -pwr_gnd_rename "\
* Configuration: VDD:VDD,GND:VSS" -prefix "" -pin_space 0.0 -name_c\
* Configuration: ase upper -check_instname on -diodes on -inside_ri\
* Configuration: ng_type GND -asvm on
* Codefile:
*
*
** begin lvs.header
** $Revision: 1.2 $
*.SCALE meter
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RA1SHD4096X32CCG BL BL_ WL WP VSS VDD
** RA1SHD4096X32CCG: 6 flat devices **
m1 BL WP CORED VSS N L=0.29U W=0.22U
m2 BL_ WP CORED_ VSS N L=0.29U W=0.22U
m3 CORED_ CORED VDD VDD P L=0.19U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.25U
m5 CORED CORED_ VDD VDD P L=0.19U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.25U
.ENDS RA1SHD4096X32CCG
****
.SUBCKT RA1SHD4096X32FCIO8 GTP OE_ WE VSS VDD
** RA1SHD4096X32FCIO8: 3 flat devices **
d1 VSS GTP DN 0.3364P 2.32U
d2 VSS OE_ DN 0.3364P 2.32U
d3 VSS WE DN 0.3364P 2.32U
.ENDS RA1SHD4096X32FCIO8
****
.SUBCKT RA1SHD4096X32FCSA8 GTP VSS VDD
** RA1SHD4096X32FCSA8: 1 flat devices **
d1 VSS GTP DN 0.3364P 2.32U
.ENDS RA1SHD4096X32FCSA8
****
.SUBCKT RA1SHD4096X32FCCDL A0 A0_ DR DR_ DW DW_ GTP VD YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32FCCDL: 2 flat devices **
d2 VSS VSS DN 0.3364P 2.32U
m1 VDD VSS VD VDD P L=0.18U W=0.22U
.ENDS RA1SHD4096X32FCCDL
****
.SUBCKT RA1SHD4096X32LEFT_CAP A0 A0_ DR DR_ DW DW_ GTP GTP_0 GTP_1 OE_ WE WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73
+  WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85
+  WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97
+  WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108
+  WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118
+  WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128
+  WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138
+  WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148
+  WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158
+  WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168
+  WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178
+  WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188
+  WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198
+  WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208
+  WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218
+  WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228
+  WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238
+  WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248
+  WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32LEFT_CAP: 1560 flat devices **
XI0_0 GTP OE_ WE VSS VDD RA1SHD4096X32FCIO8
XI0_1 GTP_0 VSS VDD RA1SHD4096X32FCSA8
XI0_10 BL BL WL_6 WL_6 VSS VDD RA1SHD4096X32CCG
XI0_100 BL BL WL_96 WL_96 VSS VDD RA1SHD4096X32CCG
XI0_101 BL BL WL_97 WL_97 VSS VDD RA1SHD4096X32CCG
XI0_102 BL BL WL_98 WL_98 VSS VDD RA1SHD4096X32CCG
XI0_103 BL BL WL_99 WL_99 VSS VDD RA1SHD4096X32CCG
XI0_104 BL BL WL_100 WL_100 VSS VDD RA1SHD4096X32CCG
XI0_105 BL BL WL_101 WL_101 VSS VDD RA1SHD4096X32CCG
XI0_106 BL BL WL_102 WL_102 VSS VDD RA1SHD4096X32CCG
XI0_107 BL BL WL_103 WL_103 VSS VDD RA1SHD4096X32CCG
XI0_108 BL BL WL_104 WL_104 VSS VDD RA1SHD4096X32CCG
XI0_109 BL BL WL_105 WL_105 VSS VDD RA1SHD4096X32CCG
XI0_11 BL BL WL_7 WL_7 VSS VDD RA1SHD4096X32CCG
XI0_110 BL BL WL_106 WL_106 VSS VDD RA1SHD4096X32CCG
XI0_111 BL BL WL_107 WL_107 VSS VDD RA1SHD4096X32CCG
XI0_112 BL BL WL_108 WL_108 VSS VDD RA1SHD4096X32CCG
XI0_113 BL BL WL_109 WL_109 VSS VDD RA1SHD4096X32CCG
XI0_114 BL BL WL_110 WL_110 VSS VDD RA1SHD4096X32CCG
XI0_115 BL BL WL_111 WL_111 VSS VDD RA1SHD4096X32CCG
XI0_116 BL BL WL_112 WL_112 VSS VDD RA1SHD4096X32CCG
XI0_117 BL BL WL_113 WL_113 VSS VDD RA1SHD4096X32CCG
XI0_118 BL BL WL_114 WL_114 VSS VDD RA1SHD4096X32CCG
XI0_119 BL BL WL_115 WL_115 VSS VDD RA1SHD4096X32CCG
XI0_12 BL BL WL_8 WL_8 VSS VDD RA1SHD4096X32CCG
XI0_120 BL BL WL_116 WL_116 VSS VDD RA1SHD4096X32CCG
XI0_121 BL BL WL_117 WL_117 VSS VDD RA1SHD4096X32CCG
XI0_122 BL BL WL_118 WL_118 VSS VDD RA1SHD4096X32CCG
XI0_123 BL BL WL_119 WL_119 VSS VDD RA1SHD4096X32CCG
XI0_124 BL BL WL_120 WL_120 VSS VDD RA1SHD4096X32CCG
XI0_125 BL BL WL_121 WL_121 VSS VDD RA1SHD4096X32CCG
XI0_126 BL BL WL_122 WL_122 VSS VDD RA1SHD4096X32CCG
XI0_127 BL BL WL_123 WL_123 VSS VDD RA1SHD4096X32CCG
XI0_128 BL BL WL_124 WL_124 VSS VDD RA1SHD4096X32CCG
XI0_129 BL BL WL_125 WL_125 VSS VDD RA1SHD4096X32CCG
XI0_13 BL BL WL_9 WL_9 VSS VDD RA1SHD4096X32CCG
XI0_130 BL BL WL_126 WL_126 VSS VDD RA1SHD4096X32CCG
XI0_131 BL BL WL_127 WL_127 VSS VDD RA1SHD4096X32CCG
XI0_132 BL BL WL_128 WL_128 VSS VDD RA1SHD4096X32CCG
XI0_133 BL BL WL_129 WL_129 VSS VDD RA1SHD4096X32CCG
XI0_134 BL BL WL_130 WL_130 VSS VDD RA1SHD4096X32CCG
XI0_135 BL BL WL_131 WL_131 VSS VDD RA1SHD4096X32CCG
XI0_136 BL BL WL_132 WL_132 VSS VDD RA1SHD4096X32CCG
XI0_137 BL BL WL_133 WL_133 VSS VDD RA1SHD4096X32CCG
XI0_138 BL BL WL_134 WL_134 VSS VDD RA1SHD4096X32CCG
XI0_139 BL BL WL_135 WL_135 VSS VDD RA1SHD4096X32CCG
XI0_14 BL BL WL_10 WL_10 VSS VDD RA1SHD4096X32CCG
XI0_140 BL BL WL_136 WL_136 VSS VDD RA1SHD4096X32CCG
XI0_141 BL BL WL_137 WL_137 VSS VDD RA1SHD4096X32CCG
XI0_142 BL BL WL_138 WL_138 VSS VDD RA1SHD4096X32CCG
XI0_143 BL BL WL_139 WL_139 VSS VDD RA1SHD4096X32CCG
XI0_144 BL BL WL_140 WL_140 VSS VDD RA1SHD4096X32CCG
XI0_145 BL BL WL_141 WL_141 VSS VDD RA1SHD4096X32CCG
XI0_146 BL BL WL_142 WL_142 VSS VDD RA1SHD4096X32CCG
XI0_147 BL BL WL_143 WL_143 VSS VDD RA1SHD4096X32CCG
XI0_148 BL BL WL_144 WL_144 VSS VDD RA1SHD4096X32CCG
XI0_149 BL BL WL_145 WL_145 VSS VDD RA1SHD4096X32CCG
XI0_15 BL BL WL_11 WL_11 VSS VDD RA1SHD4096X32CCG
XI0_150 BL BL WL_146 WL_146 VSS VDD RA1SHD4096X32CCG
XI0_151 BL BL WL_147 WL_147 VSS VDD RA1SHD4096X32CCG
XI0_152 BL BL WL_148 WL_148 VSS VDD RA1SHD4096X32CCG
XI0_153 BL BL WL_149 WL_149 VSS VDD RA1SHD4096X32CCG
XI0_154 BL BL WL_150 WL_150 VSS VDD RA1SHD4096X32CCG
XI0_155 BL BL WL_151 WL_151 VSS VDD RA1SHD4096X32CCG
XI0_156 BL BL WL_152 WL_152 VSS VDD RA1SHD4096X32CCG
XI0_157 BL BL WL_153 WL_153 VSS VDD RA1SHD4096X32CCG
XI0_158 BL BL WL_154 WL_154 VSS VDD RA1SHD4096X32CCG
XI0_159 BL BL WL_155 WL_155 VSS VDD RA1SHD4096X32CCG
XI0_16 BL BL WL_12 WL_12 VSS VDD RA1SHD4096X32CCG
XI0_160 BL BL WL_156 WL_156 VSS VDD RA1SHD4096X32CCG
XI0_161 BL BL WL_157 WL_157 VSS VDD RA1SHD4096X32CCG
XI0_162 BL BL WL_158 WL_158 VSS VDD RA1SHD4096X32CCG
XI0_163 BL BL WL_159 WL_159 VSS VDD RA1SHD4096X32CCG
XI0_164 BL BL WL_160 WL_160 VSS VDD RA1SHD4096X32CCG
XI0_165 BL BL WL_161 WL_161 VSS VDD RA1SHD4096X32CCG
XI0_166 BL BL WL_162 WL_162 VSS VDD RA1SHD4096X32CCG
XI0_167 BL BL WL_163 WL_163 VSS VDD RA1SHD4096X32CCG
XI0_168 BL BL WL_164 WL_164 VSS VDD RA1SHD4096X32CCG
XI0_169 BL BL WL_165 WL_165 VSS VDD RA1SHD4096X32CCG
XI0_17 BL BL WL_13 WL_13 VSS VDD RA1SHD4096X32CCG
XI0_170 BL BL WL_166 WL_166 VSS VDD RA1SHD4096X32CCG
XI0_171 BL BL WL_167 WL_167 VSS VDD RA1SHD4096X32CCG
XI0_172 BL BL WL_168 WL_168 VSS VDD RA1SHD4096X32CCG
XI0_173 BL BL WL_169 WL_169 VSS VDD RA1SHD4096X32CCG
XI0_174 BL BL WL_170 WL_170 VSS VDD RA1SHD4096X32CCG
XI0_175 BL BL WL_171 WL_171 VSS VDD RA1SHD4096X32CCG
XI0_176 BL BL WL_172 WL_172 VSS VDD RA1SHD4096X32CCG
XI0_177 BL BL WL_173 WL_173 VSS VDD RA1SHD4096X32CCG
XI0_178 BL BL WL_174 WL_174 VSS VDD RA1SHD4096X32CCG
XI0_179 BL BL WL_175 WL_175 VSS VDD RA1SHD4096X32CCG
XI0_18 BL BL WL_14 WL_14 VSS VDD RA1SHD4096X32CCG
XI0_180 BL BL WL_176 WL_176 VSS VDD RA1SHD4096X32CCG
XI0_181 BL BL WL_177 WL_177 VSS VDD RA1SHD4096X32CCG
XI0_182 BL BL WL_178 WL_178 VSS VDD RA1SHD4096X32CCG
XI0_183 BL BL WL_179 WL_179 VSS VDD RA1SHD4096X32CCG
XI0_184 BL BL WL_180 WL_180 VSS VDD RA1SHD4096X32CCG
XI0_185 BL BL WL_181 WL_181 VSS VDD RA1SHD4096X32CCG
XI0_186 BL BL WL_182 WL_182 VSS VDD RA1SHD4096X32CCG
XI0_187 BL BL WL_183 WL_183 VSS VDD RA1SHD4096X32CCG
XI0_188 BL BL WL_184 WL_184 VSS VDD RA1SHD4096X32CCG
XI0_189 BL BL WL_185 WL_185 VSS VDD RA1SHD4096X32CCG
XI0_19 BL BL WL_15 WL_15 VSS VDD RA1SHD4096X32CCG
XI0_190 BL BL WL_186 WL_186 VSS VDD RA1SHD4096X32CCG
XI0_191 BL BL WL_187 WL_187 VSS VDD RA1SHD4096X32CCG
XI0_192 BL BL WL_188 WL_188 VSS VDD RA1SHD4096X32CCG
XI0_193 BL BL WL_189 WL_189 VSS VDD RA1SHD4096X32CCG
XI0_194 BL BL WL_190 WL_190 VSS VDD RA1SHD4096X32CCG
XI0_195 BL BL WL_191 WL_191 VSS VDD RA1SHD4096X32CCG
XI0_196 BL BL WL_192 WL_192 VSS VDD RA1SHD4096X32CCG
XI0_197 BL BL WL_193 WL_193 VSS VDD RA1SHD4096X32CCG
XI0_198 BL BL WL_194 WL_194 VSS VDD RA1SHD4096X32CCG
XI0_199 BL BL WL_195 WL_195 VSS VDD RA1SHD4096X32CCG
XI0_2 A0 A0_ DR DR_ DW DW_ GTP_1 BL YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SHD4096X32FCCDL
XI0_20 BL BL WL_16 WL_16 VSS VDD RA1SHD4096X32CCG
XI0_200 BL BL WL_196 WL_196 VSS VDD RA1SHD4096X32CCG
XI0_201 BL BL WL_197 WL_197 VSS VDD RA1SHD4096X32CCG
XI0_202 BL BL WL_198 WL_198 VSS VDD RA1SHD4096X32CCG
XI0_203 BL BL WL_199 WL_199 VSS VDD RA1SHD4096X32CCG
XI0_204 BL BL WL_200 WL_200 VSS VDD RA1SHD4096X32CCG
XI0_205 BL BL WL_201 WL_201 VSS VDD RA1SHD4096X32CCG
XI0_206 BL BL WL_202 WL_202 VSS VDD RA1SHD4096X32CCG
XI0_207 BL BL WL_203 WL_203 VSS VDD RA1SHD4096X32CCG
XI0_208 BL BL WL_204 WL_204 VSS VDD RA1SHD4096X32CCG
XI0_209 BL BL WL_205 WL_205 VSS VDD RA1SHD4096X32CCG
XI0_21 BL BL WL_17 WL_17 VSS VDD RA1SHD4096X32CCG
XI0_210 BL BL WL_206 WL_206 VSS VDD RA1SHD4096X32CCG
XI0_211 BL BL WL_207 WL_207 VSS VDD RA1SHD4096X32CCG
XI0_212 BL BL WL_208 WL_208 VSS VDD RA1SHD4096X32CCG
XI0_213 BL BL WL_209 WL_209 VSS VDD RA1SHD4096X32CCG
XI0_214 BL BL WL_210 WL_210 VSS VDD RA1SHD4096X32CCG
XI0_215 BL BL WL_211 WL_211 VSS VDD RA1SHD4096X32CCG
XI0_216 BL BL WL_212 WL_212 VSS VDD RA1SHD4096X32CCG
XI0_217 BL BL WL_213 WL_213 VSS VDD RA1SHD4096X32CCG
XI0_218 BL BL WL_214 WL_214 VSS VDD RA1SHD4096X32CCG
XI0_219 BL BL WL_215 WL_215 VSS VDD RA1SHD4096X32CCG
XI0_22 BL BL WL_18 WL_18 VSS VDD RA1SHD4096X32CCG
XI0_220 BL BL WL_216 WL_216 VSS VDD RA1SHD4096X32CCG
XI0_221 BL BL WL_217 WL_217 VSS VDD RA1SHD4096X32CCG
XI0_222 BL BL WL_218 WL_218 VSS VDD RA1SHD4096X32CCG
XI0_223 BL BL WL_219 WL_219 VSS VDD RA1SHD4096X32CCG
XI0_224 BL BL WL_220 WL_220 VSS VDD RA1SHD4096X32CCG
XI0_225 BL BL WL_221 WL_221 VSS VDD RA1SHD4096X32CCG
XI0_226 BL BL WL_222 WL_222 VSS VDD RA1SHD4096X32CCG
XI0_227 BL BL WL_223 WL_223 VSS VDD RA1SHD4096X32CCG
XI0_228 BL BL WL_224 WL_224 VSS VDD RA1SHD4096X32CCG
XI0_229 BL BL WL_225 WL_225 VSS VDD RA1SHD4096X32CCG
XI0_23 BL BL WL_19 WL_19 VSS VDD RA1SHD4096X32CCG
XI0_230 BL BL WL_226 WL_226 VSS VDD RA1SHD4096X32CCG
XI0_231 BL BL WL_227 WL_227 VSS VDD RA1SHD4096X32CCG
XI0_232 BL BL WL_228 WL_228 VSS VDD RA1SHD4096X32CCG
XI0_233 BL BL WL_229 WL_229 VSS VDD RA1SHD4096X32CCG
XI0_234 BL BL WL_230 WL_230 VSS VDD RA1SHD4096X32CCG
XI0_235 BL BL WL_231 WL_231 VSS VDD RA1SHD4096X32CCG
XI0_236 BL BL WL_232 WL_232 VSS VDD RA1SHD4096X32CCG
XI0_237 BL BL WL_233 WL_233 VSS VDD RA1SHD4096X32CCG
XI0_238 BL BL WL_234 WL_234 VSS VDD RA1SHD4096X32CCG
XI0_239 BL BL WL_235 WL_235 VSS VDD RA1SHD4096X32CCG
XI0_24 BL BL WL_20 WL_20 VSS VDD RA1SHD4096X32CCG
XI0_240 BL BL WL_236 WL_236 VSS VDD RA1SHD4096X32CCG
XI0_241 BL BL WL_237 WL_237 VSS VDD RA1SHD4096X32CCG
XI0_242 BL BL WL_238 WL_238 VSS VDD RA1SHD4096X32CCG
XI0_243 BL BL WL_239 WL_239 VSS VDD RA1SHD4096X32CCG
XI0_244 BL BL WL_240 WL_240 VSS VDD RA1SHD4096X32CCG
XI0_245 BL BL WL_241 WL_241 VSS VDD RA1SHD4096X32CCG
XI0_246 BL BL WL_242 WL_242 VSS VDD RA1SHD4096X32CCG
XI0_247 BL BL WL_243 WL_243 VSS VDD RA1SHD4096X32CCG
XI0_248 BL BL WL_244 WL_244 VSS VDD RA1SHD4096X32CCG
XI0_249 BL BL WL_245 WL_245 VSS VDD RA1SHD4096X32CCG
XI0_25 BL BL WL_21 WL_21 VSS VDD RA1SHD4096X32CCG
XI0_250 BL BL WL_246 WL_246 VSS VDD RA1SHD4096X32CCG
XI0_251 BL BL WL_247 WL_247 VSS VDD RA1SHD4096X32CCG
XI0_252 BL BL WL_248 WL_248 VSS VDD RA1SHD4096X32CCG
XI0_253 BL BL WL_249 WL_249 VSS VDD RA1SHD4096X32CCG
XI0_254 BL BL WL_250 WL_250 VSS VDD RA1SHD4096X32CCG
XI0_255 BL BL WL_251 WL_251 VSS VDD RA1SHD4096X32CCG
XI0_256 BL BL WL_252 WL_252 VSS VDD RA1SHD4096X32CCG
XI0_257 BL BL WL_253 WL_253 VSS VDD RA1SHD4096X32CCG
XI0_258 BL BL WL_254 WL_254 VSS VDD RA1SHD4096X32CCG
XI0_259 BL BL VSS VSS VSS VDD RA1SHD4096X32CCG
XI0_26 BL BL WL_22 WL_22 VSS VDD RA1SHD4096X32CCG
XI0_260 BL BL VSS VSS VSS VDD RA1SHD4096X32CCG
XI0_261 BL BL VSS VSS VSS VDD RA1SHD4096X32CCG
XI0_27 BL BL WL_23 WL_23 VSS VDD RA1SHD4096X32CCG
XI0_28 BL BL WL_24 WL_24 VSS VDD RA1SHD4096X32CCG
XI0_29 BL BL WL_25 WL_25 VSS VDD RA1SHD4096X32CCG
XI0_3 BL BL WL WL VSS VDD RA1SHD4096X32CCG
XI0_30 BL BL WL_26 WL_26 VSS VDD RA1SHD4096X32CCG
XI0_31 BL BL WL_27 WL_27 VSS VDD RA1SHD4096X32CCG
XI0_32 BL BL WL_28 WL_28 VSS VDD RA1SHD4096X32CCG
XI0_33 BL BL WL_29 WL_29 VSS VDD RA1SHD4096X32CCG
XI0_34 BL BL WL_30 WL_30 VSS VDD RA1SHD4096X32CCG
XI0_35 BL BL WL_31 WL_31 VSS VDD RA1SHD4096X32CCG
XI0_36 BL BL WL_32 WL_32 VSS VDD RA1SHD4096X32CCG
XI0_37 BL BL WL_33 WL_33 VSS VDD RA1SHD4096X32CCG
XI0_38 BL BL WL_34 WL_34 VSS VDD RA1SHD4096X32CCG
XI0_39 BL BL WL_35 WL_35 VSS VDD RA1SHD4096X32CCG
XI0_4 BL BL WL_0 WL_0 VSS VDD RA1SHD4096X32CCG
XI0_40 BL BL WL_36 WL_36 VSS VDD RA1SHD4096X32CCG
XI0_41 BL BL WL_37 WL_37 VSS VDD RA1SHD4096X32CCG
XI0_42 BL BL WL_38 WL_38 VSS VDD RA1SHD4096X32CCG
XI0_43 BL BL WL_39 WL_39 VSS VDD RA1SHD4096X32CCG
XI0_44 BL BL WL_40 WL_40 VSS VDD RA1SHD4096X32CCG
XI0_45 BL BL WL_41 WL_41 VSS VDD RA1SHD4096X32CCG
XI0_46 BL BL WL_42 WL_42 VSS VDD RA1SHD4096X32CCG
XI0_47 BL BL WL_43 WL_43 VSS VDD RA1SHD4096X32CCG
XI0_48 BL BL WL_44 WL_44 VSS VDD RA1SHD4096X32CCG
XI0_49 BL BL WL_45 WL_45 VSS VDD RA1SHD4096X32CCG
XI0_5 BL BL WL_1 WL_1 VSS VDD RA1SHD4096X32CCG
XI0_50 BL BL WL_46 WL_46 VSS VDD RA1SHD4096X32CCG
XI0_51 BL BL WL_47 WL_47 VSS VDD RA1SHD4096X32CCG
XI0_52 BL BL WL_48 WL_48 VSS VDD RA1SHD4096X32CCG
XI0_53 BL BL WL_49 WL_49 VSS VDD RA1SHD4096X32CCG
XI0_54 BL BL WL_50 WL_50 VSS VDD RA1SHD4096X32CCG
XI0_55 BL BL WL_51 WL_51 VSS VDD RA1SHD4096X32CCG
XI0_56 BL BL WL_52 WL_52 VSS VDD RA1SHD4096X32CCG
XI0_57 BL BL WL_53 WL_53 VSS VDD RA1SHD4096X32CCG
XI0_58 BL BL WL_54 WL_54 VSS VDD RA1SHD4096X32CCG
XI0_59 BL BL WL_55 WL_55 VSS VDD RA1SHD4096X32CCG
XI0_6 BL BL WL_2 WL_2 VSS VDD RA1SHD4096X32CCG
XI0_60 BL BL WL_56 WL_56 VSS VDD RA1SHD4096X32CCG
XI0_61 BL BL WL_57 WL_57 VSS VDD RA1SHD4096X32CCG
XI0_62 BL BL WL_58 WL_58 VSS VDD RA1SHD4096X32CCG
XI0_63 BL BL WL_59 WL_59 VSS VDD RA1SHD4096X32CCG
XI0_64 BL BL WL_60 WL_60 VSS VDD RA1SHD4096X32CCG
XI0_65 BL BL WL_61 WL_61 VSS VDD RA1SHD4096X32CCG
XI0_66 BL BL WL_62 WL_62 VSS VDD RA1SHD4096X32CCG
XI0_67 BL BL WL_63 WL_63 VSS VDD RA1SHD4096X32CCG
XI0_68 BL BL WL_64 WL_64 VSS VDD RA1SHD4096X32CCG
XI0_69 BL BL WL_65 WL_65 VSS VDD RA1SHD4096X32CCG
XI0_7 BL BL WL_3 WL_3 VSS VDD RA1SHD4096X32CCG
XI0_70 BL BL WL_66 WL_66 VSS VDD RA1SHD4096X32CCG
XI0_71 BL BL WL_67 WL_67 VSS VDD RA1SHD4096X32CCG
XI0_72 BL BL WL_68 WL_68 VSS VDD RA1SHD4096X32CCG
XI0_73 BL BL WL_69 WL_69 VSS VDD RA1SHD4096X32CCG
XI0_74 BL BL WL_70 WL_70 VSS VDD RA1SHD4096X32CCG
XI0_75 BL BL WL_71 WL_71 VSS VDD RA1SHD4096X32CCG
XI0_76 BL BL WL_72 WL_72 VSS VDD RA1SHD4096X32CCG
XI0_77 BL BL WL_73 WL_73 VSS VDD RA1SHD4096X32CCG
XI0_78 BL BL WL_74 WL_74 VSS VDD RA1SHD4096X32CCG
XI0_79 BL BL WL_75 WL_75 VSS VDD RA1SHD4096X32CCG
XI0_8 BL BL WL_4 WL_4 VSS VDD RA1SHD4096X32CCG
XI0_80 BL BL WL_76 WL_76 VSS VDD RA1SHD4096X32CCG
XI0_81 BL BL WL_77 WL_77 VSS VDD RA1SHD4096X32CCG
XI0_82 BL BL WL_78 WL_78 VSS VDD RA1SHD4096X32CCG
XI0_83 BL BL WL_79 WL_79 VSS VDD RA1SHD4096X32CCG
XI0_84 BL BL WL_80 WL_80 VSS VDD RA1SHD4096X32CCG
XI0_85 BL BL WL_81 WL_81 VSS VDD RA1SHD4096X32CCG
XI0_86 BL BL WL_82 WL_82 VSS VDD RA1SHD4096X32CCG
XI0_87 BL BL WL_83 WL_83 VSS VDD RA1SHD4096X32CCG
XI0_88 BL BL WL_84 WL_84 VSS VDD RA1SHD4096X32CCG
XI0_89 BL BL WL_85 WL_85 VSS VDD RA1SHD4096X32CCG
XI0_9 BL BL WL_5 WL_5 VSS VDD RA1SHD4096X32CCG
XI0_90 BL BL WL_86 WL_86 VSS VDD RA1SHD4096X32CCG
XI0_91 BL BL WL_87 WL_87 VSS VDD RA1SHD4096X32CCG
XI0_92 BL BL WL_88 WL_88 VSS VDD RA1SHD4096X32CCG
XI0_93 BL BL WL_89 WL_89 VSS VDD RA1SHD4096X32CCG
XI0_94 BL BL WL_90 WL_90 VSS VDD RA1SHD4096X32CCG
XI0_95 BL BL WL_91 WL_91 VSS VDD RA1SHD4096X32CCG
XI0_96 BL BL WL_92 WL_92 VSS VDD RA1SHD4096X32CCG
XI0_97 BL BL WL_93 WL_93 VSS VDD RA1SHD4096X32CCG
XI0_98 BL BL WL_94 WL_94 VSS VDD RA1SHD4096X32CCG
XI0_99 BL BL WL_95 WL_95 VSS VDD RA1SHD4096X32CCG
.ENDS RA1SHD4096X32LEFT_CAP
****
.SUBCKT RA1SHD4096X32FCBWLE16 BWEN D Q VSS VDD
** RA1SHD4096X32FCBWLE16: 3 flat devices **
d1 VSS Q DN 0.3364P 2.32U
d2 VSS BWEN DN 0.3364P 2.32U
d3 VSS D DN 0.3364P 2.32U
.ENDS RA1SHD4096X32FCBWLE16
****
.SUBCKT RA1SHD4096X32FLIO GTP OE_ WE VSS VDD
** RA1SHD4096X32FLIO: 3 flat devices **
d1 VSS GTP DN 0.3364P 2.32U
d2 VSS OE_ DN 0.3364P 2.32U
d3 VSS WE DN 0.3364P 2.32U
.ENDS RA1SHD4096X32FLIO
****
.SUBCKT RA1SHD4096X32IO8 BWE BWEMX BWEN D DI_ DPN DPU DW DW_ D_ GBWEN GTP OE_
+  Q QI SP STUBWE STUBWEI UTIDMX WE VSS VDD
** RA1SHD4096X32IO8: 60 flat devices **
m1 QI DPU VSS VSS N L=0.18U W=3.47U
m10 QPD OEI_ VSS VSS N L=0.18U W=0.72U
m11 QIL QI VDD VDD P L=0.18U W=1.27U
m12 QIL QI VSS VSS N L=0.18U W=0.72U
m13 SPN SP VDD VDD P L=0.18U W=0.47U
m14 SPN SP VSS VSS N L=0.18U W=0.31U
m15 DWPD GTPND DWI VSS N L=0.18U W=0.72U
m16 DWPD DW VDD VDD P L=0.27U W=0.22U
m17 DWPD DW VSS VSS N L=0.54U W=0.22U
m18 DWPD GTP DWI VDD P L=0.18U W=0.91U
m19 DW_PU GTPND DNWI VSS N L=0.18U W=0.72U
m2 QI DPN VDD VDD P L=0.18U W=9.12U
m20 DW_PU GTP DNWI VDD P L=0.18U W=0.91U
m21 GTPND GTP VDD VDD P L=0.18U W=0.5U
m22 GTPND GTP VSS VSS N L=0.18U W=0.34U
m23 DI DI_ VDD VDD P L=0.18U W=1.82U
m24 DI DI_ VSS VSS N L=0.18U W=0.89U
m25 DN DI VDD VDD P L=0.18U W=1.25U
m26 DN DI VSS VSS N L=0.18U W=0.61U
m27 WEI N58 VDD VDD P L=0.18U W=1.47U
m28 WEI N58 VSS VSS N L=0.18U W=0.86U
m29 OEI OEI_ VDD VDD P L=0.18U W=1.23U
m3 Q QPU VDD VDD P L=0.18U W=10.8U
m30 OEI OEI_ VSS VSS N L=0.18U W=0.64U
m31 QI SP N84 VDD P L=0.18U W=2U
m32 N84 QIL VDD VDD P L=0.18U W=2U
m33 QI SPN N83 VSS N L=0.18U W=2U
m34 N83 QIL VSS VSS N L=0.18U W=2U
m35 N41 OE_ VDD VDD P L=0.18U W=0.78U
m36 N41 OE_ VSS VSS N L=0.18U W=0.4U
m37 N58 WE VDD VDD P L=0.18U W=0.58U
m38 N58 WE VSS VSS N L=0.18U W=0.29U
m39 DWI WEI VDD VDD P L=0.18U W=1.77U
m4 Q QPD VSS VSS N L=0.18U W=7.2U
m40 N85 WEI VSS VSS N L=0.18U W=1.58U
m41 DWI DI VDD VDD P L=0.18U W=1.77U
m42 DWI DI N85 VSS N L=0.18U W=1.58U
m43 DNWI WEI VDD VDD P L=0.18U W=1.77U
m44 N86 WEI VSS VSS N L=0.18U W=1.58U
m45 DNWI DN VDD VDD P L=0.18U W=1.77U
m46 DNWI DN N86 VSS N L=0.18U W=1.58U
m47 D_ D VDD VDD P L=0.18U W=0.71U
m48 D_ D VSS VSS N L=0.18U W=0.35U
m49 QPU OEI_ QI VDD P L=0.18U W=0.34U
m5 OEI_ N41 VDD VDD P L=0.18U W=2.18U
m50 QPD OEI QI VSS N L=0.18U W=0.65U
m51 DW DWPD VDD VDD P L=0.18U W=5.98U
m52 DW DWPD VSS VSS N L=0.18U W=2.95U
m53 DW_PU DW_ VDD VDD P L=0.27U W=0.22U
m54 DW_PU DW_ VSS VSS N L=0.54U W=0.22U
m55 DW_ DW_PU VDD VDD P L=0.18U W=5.98U
m56 DW_ DW_PU VSS VSS N L=0.18U W=2.95U
m57 N87 VSS VDD VDD P L=0.18U W=0.44U
m58 BWE VSS VSS VSS N L=0.18U W=0.22U
m59 BWE GBWEN N87 VDD P L=0.18U W=0.44U
m6 OEI_ N41 VSS VSS N L=0.18U W=1.11U
m60 BWE GBWEN VSS VSS N L=0.18U W=0.22U
m7 QPD OEI_ QI VDD P L=0.18U W=6.92U
m8 QPU OEI QI VSS N L=0.18U W=3.24U
m9 QPU OEI VDD VDD P L=0.18U W=1.74U
.ENDS RA1SHD4096X32IO8
****
.SUBCKT RA1SHD4096X32IOX BWE BWEN D DPN DPU DW DW_ D_ GTP OE_ Q QI SP VSS VDD
** RA1SHD4096X32IOX: 60 flat devices **
XI0_0 BWE VSS BWEN D D_ DPN DPU DW DW_ D_ BWEN GTP OE_ Q QI SP VSS VSS VSS BWE
+  VSS VDD RA1SHD4096X32IO8
.ENDS RA1SHD4096X32IOX
****
.SUBCKT RA1SHD4096X32FLSA GTP VSS VDD
** RA1SHD4096X32FLSA: 1 flat devices **
d1 VSS GTP DN 0.3364P 2.32U
.ENDS RA1SHD4096X32FLSA
****
.SUBCKT RA1SHD4096X32SA8 DPN DPU DR DR_ DW DW_ GTP SP VSS VDD
** RA1SHD4096X32SA8: 42 flat devices **
d42 VSS GTP DN 0.3364P 2.32U
m1 N23 SRCD VSS VSS N L=0.18U W=1.5U
m10 DPN SDN VDD VDD P L=0.18U W=1.54U
m11 DPN SDN VSS VSS N L=0.18U W=2.9U
m12 SP SPN VDD VDD P L=0.18U W=1.98U
m13 SP SPN VSS VSS N L=0.18U W=1.33U
m14 GTPN GTP VDD VDD P L=0.18U W=1U
m15 GTPN GTP VSS VSS N L=0.18U W=0.31U
m16 ND1 GTPN VDD VDD P L=0.18U W=0.58U
m17 ND1 GTPN VSS VSS N L=0.18U W=0.33U
m18 ND2 ND1 VDD VDD P L=0.18U W=1.65U
m19 ND2 ND1 VSS VSS N L=0.18U W=0.71U
m2 SD SP DR VDD P L=0.19U W=3.2U
m20 N41 DRP VSS VSS N L=0.18U W=1.22U
m21 SPN GTPN N41 VSS N L=0.18U W=0.83U
m22 SPN DRP VDD VDD P L=0.18U W=1.11U
m23 SPN GTPN VDD VDD P L=0.18U W=0.66U
m24 DRP ND2 VDD VDD P L=0.18U W=3U
m25 DRP ND2 VSS VSS N L=0.18U W=2.01U
m26 DR_ DRP VDD VDD P L=0.18U W=3.65U
m27 DR DRP VDD VDD P L=0.18U W=3.65U
m28 DR DRP DR_ VDD P L=0.18U W=4.68U
m29 SD_ SD SRC VSS N L=0.26U W=3.56U
m3 SD_ SP DR_ VDD P L=0.19U W=3.2U
m30 SD SD_ SRC VSS N L=0.26U W=3.56U
m31 SD_ SD SRC VSS N L=0.26U W=3.56U
m32 SD SD_ SRC VSS N L=0.26U W=3.56U
m33 SRC GTPN N23 VSS N L=0.18U W=1.65U
m34 SRCD SRCPU VDD VDD P L=0.18U W=0.62U
m35 SRCD SRCPU VSS VSS N L=0.18U W=0.22U
m36 SRCPU DRP VDD VDD P L=0.18U W=0.91U
m37 SRCPU DRP VSS VSS N L=0.18U W=0.33U
m38 VDD SRCPU SRC VSS N L=0.18U W=1.66U
m39 SD SRCD SD_ VDD P L=0.18U W=0.68U
m4 SD_ SD VDD VDD P L=0.18U W=0.68U
m40 SRC GTPN N53 VSS N L=0.18U W=1.65U
m41 N53 SRCD VSS VSS N L=0.18U W=1.5U
m5 SD SD_ VDD VDD P L=0.18U W=0.68U
m6 SDN SD VDD VDD P L=0.18U W=1.64U
m7 SDN SD VSS VSS N L=0.18U W=0.58U
m8 DPU SD_ VDD VDD P L=0.18U W=1.64U
m9 DPU SD_ VSS VSS N L=0.18U W=0.58U
.ENDS RA1SHD4096X32SA8
****
.SUBCKT RA1SHD4096X32CD A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0 G1
+  GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** RA1SHD4096X32CD: 43 flat devices **
m1 BL0_ CS0 DR_ VDD P L=0.18U W=3.24U
m10 BL1_ BL1PD VSS VSS N L=0.18U W=6.72U
m11 BL1_PD CS1 DW_ VDD P L=0.18U W=1.72U
m12 BL1_PD CS1 VSS VSS N L=0.18U W=0.88U
m13 BL1_ CS1 DR_ VDD P L=0.18U W=3.24U
m14 BL1PD CS1 DW VDD P L=0.18U W=1.72U
m15 BL1PD CS1 VSS VSS N L=0.18U W=0.88U
m16 BL1 BL1_PD VSS VSS N L=0.18U W=6.72U
m17 BL0_ YI VDD VDD P L=0.18U W=11.8U
m18 BL0 YI VDD VDD P L=0.18U W=11.8U
m19 BL0 YI BL0_ VDD P L=0.18U W=11.8U
m2 BL0 BL0PD VSS VSS N L=0.18U W=6.72U
m20 BL1 YI VDD VDD P L=0.18U W=11.8U
m21 BL1_ YI VDD VDD P L=0.18U W=11.8U
m22 BL1_ YI BL1 VDD P L=0.18U W=11.8U
m23 CS0 A0_ VDD VDD P L=0.18U W=2.09U
m24 N65 A0_ VSS VSS N L=0.18U W=2.13U
m25 CS0 YI VDD VDD P L=0.18U W=2.09U
m26 CS0 YI N65 VSS N L=0.18U W=2.13U
m27 CS1 A0 VDD VDD P L=0.18U W=2.09U
m28 N66 A0 VSS VSS N L=0.18U W=2.13U
m29 CS1 YI VDD VDD P L=0.18U W=2.09U
m3 BL0_PD CS0 DW VDD P L=0.18U W=1.72U
m30 CS1 YI N66 VSS N L=0.18U W=2.13U
m31 YCDSEL_ G0 VDD VDD P L=0.18U W=0.81U
m32 N67 G0 VSS VSS N L=0.18U W=0.76U
m33 YCDSEL_ G1 VDD VDD P L=0.18U W=0.81U
m34 YCDSEL_ G1 N67 VSS N L=0.18U W=0.76U
m35 YCDSEL YCDSEL_ VDD VDD P L=0.18U W=0.47U
m36 YCDSEL YCDSEL_ VSS VSS N L=0.18U W=0.22U
m37 N37 YCDSEL_ GTP VDD P L=0.18U W=0.66U
m38 N37 YCDSEL_ VSS VSS N L=0.18U W=1.06U
m39 YI WL1_EN_ VDD VDD P L=0.18U W=13.14U
m4 BL0_PD CS0 VSS VSS N L=0.18U W=0.88U
m40 YI WL1_EN_ VSS VSS N L=0.18U W=7.69U
m41 WL1_EN_ N37 VDD VDD P L=0.18U W=4U
m42 WL1_EN_ N37 VSS VSS N L=0.18U W=2.97U
m43 N37 YCDSEL GTP VSS N L=0.18U W=0.66U
m5 BL0 CS0 DR VDD P L=0.18U W=3.24U
m6 BL0PD CS0 DW_ VDD P L=0.18U W=1.72U
m7 BL0PD CS0 VSS VSS N L=0.18U W=0.88U
m8 BL0_ BL0_PD VSS VSS N L=0.18U W=6.72U
m9 BL1 CS1 DR VDD P L=0.18U W=3.24U
.ENDS RA1SHD4096X32CD
****
.SUBCKT RA1SHD4096X32CDX A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0
+  G1 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32CDX: 43 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0 G1 GTP DR DR_ DW DW_
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32CD
.ENDS RA1SHD4096X32CDX
****
.SUBCKT RA1SHD4096X32MUX_CD_EVEN A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL1 BL1_ BL1_0
+  BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4
+  BL1__5 BL1__6 DRSA DRSA_0 DRSA_1 DRSA_2 DRSA_3 DRSA_4 DRSA_5 DRSA_6 DWSA
+  DWSA_0 DWSA_1 DWSA_2 DWSA_3 DWSA_4 DWSA_5 DWSA_6 GTP STUBDR STUBDR_ STUBDW
+  STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32MUX_CD_EVEN: 344 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL1 BL1_ DRSA_4 DRSA DRSA_5 DWSA_4 DWSA DWSA_5 YP0_0 VDD
+  GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32CDX
XI1_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 DRSA_4 DRSA_0 DRSA_5 DWSA_4 DWSA_0
+  DWSA_5 YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI2_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 DRSA_4 DRSA_1 DRSA_5 DWSA_4 DWSA_1
+  DWSA_5 YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI3_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 DRSA_4 DRSA_2 DRSA_5 DWSA_4 DWSA_2
+  DWSA_5 YP0_3 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI4_0 A0 A0_ BL0_3 BL0__3 BL1_3 BL1__3 DRSA_4 DRSA_3 DRSA_5 DWSA_4 DWSA_3
+  DWSA_5 VDD YP1_0 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI5_0 A0 A0_ BL0_4 BL0__4 BL1_4 BL1__4 DRSA_4 DRSA_4 DRSA_5 DWSA_4 DWSA_4
+  DWSA_5 VDD YP1_1 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI6_0 A0 A0_ BL0_5 BL0__5 BL1_5 BL1__5 DRSA_4 DRSA_5 DRSA_5 DWSA_4 DWSA_5
+  DWSA_5 VDD YP1_2 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI7_0 A0 A0_ BL0_6 BL0__6 BL1_6 BL1__6 DRSA_4 DRSA_6 DRSA_5 DWSA_4 DWSA_6
+  DWSA_5 VDD YP1_3 GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32CD
.ENDS RA1SHD4096X32MUX_CD_EVEN
****
.SUBCKT RA1SHD4096X32CCP BL BL_ WL WP VSS VDD
** RA1SHD4096X32CCP: 6 flat devices **
m1 BL WP CORED VSS N L=0.29U W=0.22U
m2 BL_ WP CORED_ VSS N L=0.29U W=0.22U
m3 CORED_ CORED VDD VDD P L=0.19U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.25U
m5 CORED CORED_ VDD VDD P L=0.19U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.25U
.ENDS RA1SHD4096X32CCP
****
.SUBCKT RA1SHD4096X32BIT_MUX_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL WP VSS VDD
** RA1SHD4096X32BIT_MUX_1: 96 flat devices **
XI0_0 BL BL_ WL WP VSS VDD RA1SHD4096X32CCG
XI10_0 BL_9 BL__9 WL WP VSS VDD RA1SHD4096X32CCP
XI11_0 BL_10 BL__10 WL WP VSS VDD RA1SHD4096X32CCG
XI12_0 BL_11 BL__11 WL WP VSS VDD RA1SHD4096X32CCG
XI13_0 BL_12 BL__12 WL WP VSS VDD RA1SHD4096X32CCP
XI14_0 BL_13 BL__13 WL WP VSS VDD RA1SHD4096X32CCP
XI15_0 BL_14 BL__14 WL WP VSS VDD RA1SHD4096X32CCG
XI1_0 BL_0 BL__0 WL WP VSS VDD RA1SHD4096X32CCP
XI2_0 BL_1 BL__1 WL WP VSS VDD RA1SHD4096X32CCP
XI3_0 BL_2 BL__2 WL WP VSS VDD RA1SHD4096X32CCG
XI4_0 BL_3 BL__3 WL WP VSS VDD RA1SHD4096X32CCG
XI5_0 BL_4 BL__4 WL WP VSS VDD RA1SHD4096X32CCP
XI6_0 BL_5 BL__5 WL WP VSS VDD RA1SHD4096X32CCP
XI7_0 BL_6 BL__6 WL WP VSS VDD RA1SHD4096X32CCG
XI8_0 BL_7 BL__7 WL WP VSS VDD RA1SHD4096X32CCG
XI9_0 BL_8 BL__8 WL WP VSS VDD RA1SHD4096X32CCP
.ENDS RA1SHD4096X32BIT_MUX_1
****
.SUBCKT RA1SHD4096X32BIT_MUX_0 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL WP VSS VDD
** RA1SHD4096X32BIT_MUX_0: 96 flat devices **
XI0_0 BL BL_ WL WP VSS VDD RA1SHD4096X32CCG
XI10_0 BL_9 BL__9 WL WP VSS VDD RA1SHD4096X32CCP
XI11_0 BL_10 BL__10 WL WP VSS VDD RA1SHD4096X32CCG
XI12_0 BL_11 BL__11 WL WP VSS VDD RA1SHD4096X32CCG
XI13_0 BL_12 BL__12 WL WP VSS VDD RA1SHD4096X32CCP
XI14_0 BL_13 BL__13 WL WP VSS VDD RA1SHD4096X32CCP
XI15_0 BL_14 BL__14 WL WP VSS VDD RA1SHD4096X32CCG
XI1_0 BL_0 BL__0 WL WP VSS VDD RA1SHD4096X32CCP
XI2_0 BL_1 BL__1 WL WP VSS VDD RA1SHD4096X32CCP
XI3_0 BL_2 BL__2 WL WP VSS VDD RA1SHD4096X32CCG
XI4_0 BL_3 BL__3 WL WP VSS VDD RA1SHD4096X32CCG
XI5_0 BL_4 BL__4 WL WP VSS VDD RA1SHD4096X32CCP
XI6_0 BL_5 BL__5 WL WP VSS VDD RA1SHD4096X32CCP
XI7_0 BL_6 BL__6 WL WP VSS VDD RA1SHD4096X32CCG
XI8_0 BL_7 BL__7 WL WP VSS VDD RA1SHD4096X32CCG
XI9_0 BL_8 BL__8 WL WP VSS VDD RA1SHD4096X32CCP
.ENDS RA1SHD4096X32BIT_MUX_0
****
.SUBCKT RA1SHD4096X32BIT_COL BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6
+  WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19
+  WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31
+  WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43
+  WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55
+  WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67
+  WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79
+  WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91
+  WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103
+  WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113
+  WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123
+  WP_124 WP_125 WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132 WP_133
+  WP_134 WP_135 WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142 WP_143
+  WP_144 WP_145 WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152 WP_153
+  WP_154 WP_155 WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162 WP_163
+  WP_164 WP_165 WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172 WP_173
+  WP_174 WP_175 WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182 WP_183
+  WP_184 WP_185 WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192 WP_193
+  WP_194 WP_195 WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202 WP_203
+  WP_204 WP_205 WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212 WP_213
+  WP_214 WP_215 WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222 WP_223
+  WP_224 WP_225 WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232 WP_233
+  WP_234 WP_235 WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242 WP_243
+  WP_244 WP_245 WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252 WP_253
+  WP_254 VSS VDD
** RA1SHD4096X32BIT_COL: 24576 flat devices **
XI0_0 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL WP VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_0 WP_0 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_10 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_9 WP_9 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_100 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_99 WP_99 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_101 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_100 WP_100 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_102 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_101 WP_101 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_103 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_102 WP_102 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_104 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_103 WP_103 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_105 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_104 WP_104 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_106 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_105 WP_105 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_107 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_106 WP_106 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_108 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_107 WP_107 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_109 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_108 WP_108 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_11 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_10 WP_10 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_110 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_109 WP_109 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_111 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_110 WP_110 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_112 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_111 WP_111 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_113 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_112 WP_112 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_114 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_113 WP_113 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_115 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_114 WP_114 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_116 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_115 WP_115 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_117 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_116 WP_116 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_118 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_117 WP_117 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_119 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_118 WP_118 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_12 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_11 WP_11 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_120 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_119 WP_119 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_121 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_120 WP_120 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_122 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_121 WP_121 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_123 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_122 WP_122 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_124 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_123 WP_123 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_125 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_124 WP_124 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_126 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_125 WP_125 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_127 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_126 WP_126 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_128 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_127 WP_127 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_129 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_128 WP_128 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_13 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_12 WP_12 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_130 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_129 WP_129 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_131 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_130 WP_130 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_132 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_131 WP_131 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_133 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_132 WP_132 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_134 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_133 WP_133 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_135 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_134 WP_134 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_136 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_135 WP_135 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_137 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_136 WP_136 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_138 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_137 WP_137 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_139 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_138 WP_138 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_14 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_13 WP_13 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_140 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_139 WP_139 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_141 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_140 WP_140 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_142 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_141 WP_141 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_143 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_142 WP_142 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_144 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_143 WP_143 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_145 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_144 WP_144 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_146 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_145 WP_145 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_147 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_146 WP_146 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_148 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_147 WP_147 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_149 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_148 WP_148 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_15 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_14 WP_14 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_150 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_149 WP_149 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_151 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_150 WP_150 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_152 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_151 WP_151 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_153 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_152 WP_152 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_154 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_153 WP_153 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_155 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_154 WP_154 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_156 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_155 WP_155 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_157 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_156 WP_156 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_158 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_157 WP_157 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_159 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_158 WP_158 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_16 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_15 WP_15 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_160 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_159 WP_159 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_161 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_160 WP_160 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_162 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_161 WP_161 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_163 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_162 WP_162 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_164 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_163 WP_163 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_165 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_164 WP_164 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_166 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_165 WP_165 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_167 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_166 WP_166 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_168 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_167 WP_167 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_169 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_168 WP_168 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_17 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_16 WP_16 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_170 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_169 WP_169 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_171 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_170 WP_170 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_172 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_171 WP_171 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_173 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_172 WP_172 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_174 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_173 WP_173 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_175 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_174 WP_174 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_176 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_175 WP_175 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_177 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_176 WP_176 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_178 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_177 WP_177 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_179 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_178 WP_178 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_18 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_17 WP_17 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_180 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_179 WP_179 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_181 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_180 WP_180 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_182 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_181 WP_181 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_183 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_182 WP_182 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_184 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_183 WP_183 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_185 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_184 WP_184 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_186 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_185 WP_185 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_187 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_186 WP_186 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_188 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_187 WP_187 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_189 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_188 WP_188 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_19 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_18 WP_18 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_190 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_189 WP_189 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_191 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_190 WP_190 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_192 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_191 WP_191 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_193 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_192 WP_192 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_194 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_193 WP_193 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_195 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_194 WP_194 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_196 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_195 WP_195 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_197 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_196 WP_196 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_198 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_197 WP_197 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_199 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_198 WP_198 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_2 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_1 WP_1 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_20 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_19 WP_19 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_200 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_199 WP_199 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_201 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_200 WP_200 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_202 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_201 WP_201 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_203 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_202 WP_202 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_204 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_203 WP_203 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_205 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_204 WP_204 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_206 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_205 WP_205 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_207 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_206 WP_206 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_208 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_207 WP_207 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_209 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_208 WP_208 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_21 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_20 WP_20 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_210 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_209 WP_209 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_211 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_210 WP_210 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_212 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_211 WP_211 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_213 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_212 WP_212 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_214 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_213 WP_213 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_215 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_214 WP_214 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_216 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_215 WP_215 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_217 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_216 WP_216 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_218 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_217 WP_217 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_219 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_218 WP_218 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_22 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_21 WP_21 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_220 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_219 WP_219 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_221 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_220 WP_220 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_222 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_221 WP_221 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_223 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_222 WP_222 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_224 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_223 WP_223 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_225 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_224 WP_224 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_226 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_225 WP_225 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_227 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_226 WP_226 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_228 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_227 WP_227 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_229 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_228 WP_228 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_23 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_22 WP_22 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_230 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_229 WP_229 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_231 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_230 WP_230 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_232 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_231 WP_231 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_233 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_232 WP_232 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_234 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_233 WP_233 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_235 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_234 WP_234 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_236 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_235 WP_235 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_237 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_236 WP_236 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_238 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_237 WP_237 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_239 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_238 WP_238 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_24 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_23 WP_23 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_240 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_239 WP_239 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_241 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_240 WP_240 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_242 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_241 WP_241 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_243 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_242 WP_242 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_244 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_243 WP_243 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_245 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_244 WP_244 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_246 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_245 WP_245 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_247 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_246 WP_246 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_248 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_247 WP_247 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_249 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_248 WP_248 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_25 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_24 WP_24 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_250 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_249 WP_249 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_251 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_250 WP_250 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_252 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_251 WP_251 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_253 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_252 WP_252 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_254 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_253 WP_253 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_255 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_254 WP_254 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_26 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_25 WP_25 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_27 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_26 WP_26 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_28 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_27 WP_27 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_29 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_28 WP_28 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_3 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_2 WP_2 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_30 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_29 WP_29 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_31 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_30 WP_30 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_32 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_31 WP_31 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_33 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_32 WP_32 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_34 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_33 WP_33 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_35 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_34 WP_34 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_36 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_35 WP_35 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_37 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_36 WP_36 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_38 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_37 WP_37 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_39 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_38 WP_38 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_4 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_3 WP_3 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_40 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_39 WP_39 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_41 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_40 WP_40 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_42 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_41 WP_41 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_43 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_42 WP_42 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_44 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_43 WP_43 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_45 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_44 WP_44 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_46 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_45 WP_45 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_47 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_46 WP_46 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_48 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_47 WP_47 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_49 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_48 WP_48 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_5 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_4 WP_4 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_50 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_49 WP_49 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_51 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_50 WP_50 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_52 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_51 WP_51 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_53 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_52 WP_52 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_54 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_53 WP_53 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_55 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_54 WP_54 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_56 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_55 WP_55 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_57 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_56 WP_56 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_58 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_57 WP_57 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_59 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_58 WP_58 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_6 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_5 WP_5 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_60 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_59 WP_59 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_61 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_60 WP_60 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_62 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_61 WP_61 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_63 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_62 WP_62 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_64 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_63 WP_63 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_65 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_64 WP_64 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_66 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_65 WP_65 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_67 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_66 WP_66 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_68 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_67 WP_67 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_69 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_68 WP_68 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_7 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_6 WP_6 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_70 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_69 WP_69 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_71 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_70 WP_70 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_72 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_71 WP_71 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_73 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_72 WP_72 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_74 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_73 WP_73 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_75 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_74 WP_74 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_76 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_75 WP_75 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_77 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_76 WP_76 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_78 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_77 WP_77 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_79 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_78 WP_78 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_8 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_7 WP_7 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_80 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_79 WP_79 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_81 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_80 WP_80 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_82 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_81 WP_81 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_83 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_82 WP_82 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_84 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_83 WP_83 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_85 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_84 WP_84 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_86 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_85 WP_85 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_87 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_86 WP_86 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_88 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_87 WP_87 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_89 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_88 WP_88 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_9 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_8 WP_8 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_90 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_89 WP_89 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_91 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_90 WP_90 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_92 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_91 WP_91 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_93 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_92 WP_92 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_94 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_93 WP_93 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_95 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_94 WP_94 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_96 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_95 WP_95 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_97 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_96 WP_96 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
XI0_98 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL_97 WP_97 VSS VDD
+  RA1SHD4096X32BIT_MUX_0
XI0_99 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL_98 WP_98 VSS VDD
+  RA1SHD4096X32BIT_MUX_1
.ENDS RA1SHD4096X32BIT_COL
****
.SUBCKT RA1SHD4096X32MCOL_EVEN_LE16 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4
+  BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2
+  BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13
+  BL__14 BWEN D GTP GTP_0 GTP_1 OE_ Q STUBDR STUBDR_ STUBDR_0 STUBDR__0
+  STUBDW STUBDW_ STUBDW_0 STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11
+  WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23
+  WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35
+  WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47
+  WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59
+  WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71
+  WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83
+  WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95
+  WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106
+  WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116
+  WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126
+  WP_127 WP_128 WP_129 WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136
+  WP_137 WP_138 WP_139 WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146
+  WP_147 WP_148 WP_149 WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156
+  WP_157 WP_158 WP_159 WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166
+  WP_167 WP_168 WP_169 WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176
+  WP_177 WP_178 WP_179 WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186
+  WP_187 WP_188 WP_189 WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196
+  WP_197 WP_198 WP_199 WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206
+  WP_207 WP_208 WP_209 WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216
+  WP_217 WP_218 WP_219 WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226
+  WP_227 WP_228 WP_229 WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236
+  WP_237 WP_238 WP_239 WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246
+  WP_247 WP_248 WP_249 WP_250 WP_251 WP_252 WP_253 WP_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32MCOL_EVEN_LE16: 25029 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SHD4096X32FCBWLE16
XI0_1 GTP OE_ VSS VSS VDD RA1SHD4096X32FLIO
XI0_2 GTP_0 VSS VDD RA1SHD4096X32FLSA
XI0_3 A0 A0_ BL_ BL BL_2 BL__3 BL_6 BL__7 BL_10 BL__11 BL_14 BL__2 BL_3 BL__6
+  BL_7 BL__10 BL_11 BL__14 BL_0 BL__0 BL__1 BL_4 BL__5 BL_8 BL__9 BL_12
+  BL__13 BL_1 BL__4 BL_5 BL__8 BL_9 BL__12 BL_13 VSS VSS VSS VSS VSS STUBDR_0
+  STUBDR__0 VSS VSS VSS VSS VSS VSS STUBDW_0 STUBDW__0 VSS GTP_1 STUBDR
+  STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32MUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66
+  WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78
+  WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90
+  WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102
+  WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112
+  WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122
+  WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132
+  WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142
+  WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152
+  WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162
+  WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172
+  WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182
+  WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192
+  WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202
+  WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212
+  WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222
+  WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232
+  WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242
+  WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252
+  WL_253 WL_254 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10
+  WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22
+  WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34
+  WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46
+  WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58
+  WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70
+  WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82
+  WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94
+  WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105
+  WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115
+  WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125
+  WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132 WP_133 WP_134 WP_135
+  WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142 WP_143 WP_144 WP_145
+  WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152 WP_153 WP_154 WP_155
+  WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162 WP_163 WP_164 WP_165
+  WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172 WP_173 WP_174 WP_175
+  WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182 WP_183 WP_184 WP_185
+  WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192 WP_193 WP_194 WP_195
+  WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202 WP_203 WP_204 WP_205
+  WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212 WP_213 WP_214 WP_215
+  WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222 WP_223 WP_224 WP_225
+  WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232 WP_233 WP_234 WP_235
+  WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242 WP_243 WP_244 WP_245
+  WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252 WP_253 WP_254 VSS VDD
+  RA1SHD4096X32BIT_COL
XI1_1 BWE BWEN D DPN DPU STUBDW_0 STUBDW__0 D_ GTP OE_ Q QI SP VSS VDD
+  RA1SHD4096X32IOX
XI1_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_0 SP VSS VDD
+  RA1SHD4096X32SA8
.ENDS RA1SHD4096X32MCOL_EVEN_LE16
****
.SUBCKT RA1SHD4096X32FCBWRO16 BWEN D Q VSS VDD
** RA1SHD4096X32FCBWRO16: 2 flat devices **
d1 VSS Q DN 0.3364P 2.32U
d2 VSS D DN 0.3364P 2.32U
.ENDS RA1SHD4096X32FCBWRO16
****
.SUBCKT RA1SHD4096X32MUX_CD_ODD A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL1 BL1_ BL1_0
+  BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4
+  BL1__5 BL1__6 DRSA DRSA_0 DRSA_1 DRSA_2 DRSA_3 DRSA_4 DWSA DWSA_0 DWSA_1
+  DWSA_2 DWSA_3 DWSA_4 GTP STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_
+  STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32MUX_CD_ODD: 344 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL1 BL1_ STUBDR DRSA STUBDR_ STUBDW DWSA STUBDW_ VDD
+  YP1_3 GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32CD
XI1_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 STUBDR DRSA_0 STUBDR_ STUBDW DWSA_0
+  STUBDW_ VDD YP1_2 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI2_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 STUBDR DRSA_1 STUBDR_ STUBDW DWSA_1
+  STUBDW_ VDD YP1_1 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI3_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 STUBDR DRSA_2 STUBDR_ STUBDW DWSA_2
+  STUBDW_ VDD YP1_0 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI4_0 A0 A0_ BL0_3 BL0__3 BL1_3 BL1__3 STUBDR DRSA_3 STUBDR_ STUBDW DWSA_3
+  STUBDW_ YP0_3 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI5_0 A0 A0_ BL0_4 BL0__4 BL1_4 BL1__4 STUBDR STUBDR STUBDR_ STUBDW STUBDW
+  STUBDW_ YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI6_0 A0 A0_ BL0_5 BL0__5 BL1_5 BL1__5 STUBDR STUBDR_ STUBDR_ STUBDW STUBDW_
+  STUBDW_ YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
XI7_0 A0 A0_ BL0_6 BL0__6 BL1_6 BL1__6 STUBDR DRSA_4 STUBDR_ STUBDW DWSA_4
+  STUBDW_ YP0_0 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32CDX
.ENDS RA1SHD4096X32MUX_CD_ODD
****
.SUBCKT RA1SHD4096X32MCOL_ODD_RO16 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BWEN
+  D GTP GTP_0 GTP_1 OE_ Q STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_
+  STUBDW_0 STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WP
+  WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13
+  WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25
+  WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37
+  WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49
+  WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61
+  WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73
+  WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85
+  WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97
+  WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108
+  WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118
+  WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128
+  WP_129 WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138
+  WP_139 WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148
+  WP_149 WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158
+  WP_159 WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168
+  WP_169 WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178
+  WP_179 WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188
+  WP_189 WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198
+  WP_199 WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208
+  WP_209 WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218
+  WP_219 WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228
+  WP_229 WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238
+  WP_239 WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248
+  WP_249 WP_250 WP_251 WP_252 WP_253 WP_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32MCOL_ODD_RO16: 25028 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SHD4096X32FCBWRO16
XI0_1 GTP OE_ VSS VSS VDD RA1SHD4096X32FLIO
XI0_2 GTP_0 VSS VDD RA1SHD4096X32FLSA
XI0_3 A0 A0_ BL_ BL BL_2 BL__3 BL_6 BL__7 BL_10 BL__11 BL_14 BL__2 BL_3 BL__6
+  BL_7 BL__10 BL_11 BL__14 BL_0 BL__0 BL__1 BL_4 BL__5 BL_8 BL__9 BL_12
+  BL__13 BL_1 BL__4 BL_5 BL__8 BL_9 BL__12 BL_13 VSS VSS VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS GTP_1 STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_
+  STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MUX_CD_ODD
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66
+  WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78
+  WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90
+  WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102
+  WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112
+  WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122
+  WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132
+  WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142
+  WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152
+  WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162
+  WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172
+  WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182
+  WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192
+  WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202
+  WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212
+  WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222
+  WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232
+  WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242
+  WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252
+  WL_253 WL_254 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10
+  WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22
+  WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34
+  WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46
+  WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58
+  WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70
+  WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82
+  WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94
+  WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105
+  WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115
+  WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125
+  WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132 WP_133 WP_134 WP_135
+  WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142 WP_143 WP_144 WP_145
+  WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152 WP_153 WP_154 WP_155
+  WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162 WP_163 WP_164 WP_165
+  WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172 WP_173 WP_174 WP_175
+  WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182 WP_183 WP_184 WP_185
+  WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192 WP_193 WP_194 WP_195
+  WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202 WP_203 WP_204 WP_205
+  WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212 WP_213 WP_214 WP_215
+  WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222 WP_223 WP_224 WP_225
+  WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232 WP_233 WP_234 WP_235
+  WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242 WP_243 WP_244 WP_245
+  WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252 WP_253 WP_254 VSS VDD
+  RA1SHD4096X32BIT_COL
XI1_1 BWE BWEN D DPN DPU STUBDW STUBDW_ D_ GTP OE_ Q QI SP VSS VDD
+  RA1SHD4096X32IOX
XI1_2 DPN DPU STUBDR STUBDR_ STUBDW STUBDW_ GTP_0 SP VSS VDD RA1SHD4096X32SA8
.ENDS RA1SHD4096X32MCOL_ODD_RO16
****
.SUBCKT RA1SHD4096X32FCBWM16 BWEN D Q VSS VDD
** RA1SHD4096X32FCBWM16: 2 flat devices **
d1 VSS Q DN 0.3364P 2.32U
d2 VSS D DN 0.3364P 2.32U
.ENDS RA1SHD4096X32FCBWM16
****
.SUBCKT RA1SHD4096X32MCOL_EVEN_M16 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BWEN
+  D GTP GTP_0 GTP_1 OE_ Q STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_
+  STUBDW_0 STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WP
+  WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13
+  WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25
+  WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37
+  WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49
+  WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61
+  WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73
+  WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85
+  WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97
+  WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108
+  WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118
+  WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128
+  WP_129 WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138
+  WP_139 WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148
+  WP_149 WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158
+  WP_159 WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168
+  WP_169 WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178
+  WP_179 WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188
+  WP_189 WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198
+  WP_199 WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208
+  WP_209 WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218
+  WP_219 WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228
+  WP_229 WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238
+  WP_239 WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248
+  WP_249 WP_250 WP_251 WP_252 WP_253 WP_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32MCOL_EVEN_M16: 25028 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SHD4096X32FCBWM16
XI0_1 GTP OE_ VSS VSS VDD RA1SHD4096X32FLIO
XI0_2 GTP_0 VSS VDD RA1SHD4096X32FLSA
XI0_3 A0 A0_ BL_ BL BL_2 BL__3 BL_6 BL__7 BL_10 BL__11 BL_14 BL__2 BL_3 BL__6
+  BL_7 BL__10 BL_11 BL__14 BL_0 BL__0 BL__1 BL_4 BL__5 BL_8 BL__9 BL_12
+  BL__13 BL_1 BL__4 BL_5 BL__8 BL_9 BL__12 BL_13 VSS VSS VSS VSS VSS STUBDR_0
+  STUBDR__0 VSS VSS VSS VSS VSS VSS STUBDW_0 STUBDW__0 VSS GTP_1 STUBDR
+  STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD4096X32MUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66
+  WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78
+  WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90
+  WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102
+  WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112
+  WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122
+  WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132
+  WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142
+  WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152
+  WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162
+  WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172
+  WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182
+  WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192
+  WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202
+  WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212
+  WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222
+  WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232
+  WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242
+  WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252
+  WL_253 WL_254 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10
+  WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22
+  WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34
+  WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46
+  WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58
+  WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70
+  WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82
+  WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94
+  WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105
+  WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115
+  WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125
+  WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132 WP_133 WP_134 WP_135
+  WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142 WP_143 WP_144 WP_145
+  WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152 WP_153 WP_154 WP_155
+  WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162 WP_163 WP_164 WP_165
+  WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172 WP_173 WP_174 WP_175
+  WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182 WP_183 WP_184 WP_185
+  WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192 WP_193 WP_194 WP_195
+  WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202 WP_203 WP_204 WP_205
+  WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212 WP_213 WP_214 WP_215
+  WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222 WP_223 WP_224 WP_225
+  WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232 WP_233 WP_234 WP_235
+  WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242 WP_243 WP_244 WP_245
+  WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252 WP_253 WP_254 VSS VDD
+  RA1SHD4096X32BIT_COL
XI1_1 BWE BWEN D DPN DPU STUBDW_0 STUBDW__0 D_ GTP OE_ Q QI SP VSS VDD
+  RA1SHD4096X32IOX
XI1_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_0 SP VSS VDD
+  RA1SHD4096X32SA8
.ENDS RA1SHD4096X32MCOL_EVEN_M16
****
.SUBCKT RA1SHD4096X32MCOL_ODD_M16 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BWEN
+  D GTP GTP_0 GTP_1 OE_ Q STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_
+  STUBDW_0 STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WP
+  WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13
+  WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25
+  WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37
+  WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49
+  WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61
+  WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73
+  WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85
+  WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97
+  WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108
+  WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118
+  WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128
+  WP_129 WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138
+  WP_139 WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148
+  WP_149 WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158
+  WP_159 WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168
+  WP_169 WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178
+  WP_179 WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188
+  WP_189 WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198
+  WP_199 WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208
+  WP_209 WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218
+  WP_219 WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228
+  WP_229 WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238
+  WP_239 WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248
+  WP_249 WP_250 WP_251 WP_252 WP_253 WP_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32MCOL_ODD_M16: 25028 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SHD4096X32FCBWM16
XI0_1 GTP OE_ VSS VSS VDD RA1SHD4096X32FLIO
XI0_2 GTP_0 VSS VDD RA1SHD4096X32FLSA
XI0_3 A0 A0_ BL_ BL BL_2 BL__3 BL_6 BL__7 BL_10 BL__11 BL_14 BL__2 BL_3 BL__6
+  BL_7 BL__10 BL_11 BL__14 BL_0 BL__0 BL__1 BL_4 BL__5 BL_8 BL__9 BL_12
+  BL__13 BL_1 BL__4 BL_5 BL__8 BL_9 BL__12 BL_13 VSS VSS VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS GTP_1 STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_
+  STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MUX_CD_ODD
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66
+  WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78
+  WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90
+  WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102
+  WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112
+  WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122
+  WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132
+  WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142
+  WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152
+  WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162
+  WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172
+  WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182
+  WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192
+  WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202
+  WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212
+  WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222
+  WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232
+  WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242
+  WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252
+  WL_253 WL_254 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10
+  WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22
+  WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34
+  WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46
+  WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58
+  WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70
+  WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82
+  WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94
+  WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105
+  WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115
+  WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125
+  WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132 WP_133 WP_134 WP_135
+  WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142 WP_143 WP_144 WP_145
+  WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152 WP_153 WP_154 WP_155
+  WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162 WP_163 WP_164 WP_165
+  WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172 WP_173 WP_174 WP_175
+  WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182 WP_183 WP_184 WP_185
+  WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192 WP_193 WP_194 WP_195
+  WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202 WP_203 WP_204 WP_205
+  WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212 WP_213 WP_214 WP_215
+  WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222 WP_223 WP_224 WP_225
+  WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232 WP_233 WP_234 WP_235
+  WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242 WP_243 WP_244 WP_245
+  WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252 WP_253 WP_254 VSS VDD
+  RA1SHD4096X32BIT_COL
XI1_1 BWE BWEN D DPN DPU STUBDW STUBDW_ D_ GTP OE_ Q QI SP VSS VDD
+  RA1SHD4096X32IOX
XI1_2 DPN DPU STUBDR STUBDR_ STUBDW STUBDW_ GTP_0 SP VSS VDD RA1SHD4096X32SA8
.ENDS RA1SHD4096X32MCOL_ODD_M16
****
.SUBCKT RA1SHD4096X32WING_16_LEFT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42
+  BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54
+  BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66
+  BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78
+  BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90
+  BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102
+  BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112
+  BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122
+  BL_123 BL_124 BL_125 BL_126 BL_127 BL_128 BL_129 BL_130 BL_131 BL_132
+  BL_133 BL_134 BL_135 BL_136 BL_137 BL_138 BL_139 BL_140 BL_141 BL_142
+  BL_143 BL_144 BL_145 BL_146 BL_147 BL_148 BL_149 BL_150 BL_151 BL_152
+  BL_153 BL_154 BL_155 BL_156 BL_157 BL_158 BL_159 BL_160 BL_161 BL_162
+  BL_163 BL_164 BL_165 BL_166 BL_167 BL_168 BL_169 BL_170 BL_171 BL_172
+  BL_173 BL_174 BL_175 BL_176 BL_177 BL_178 BL_179 BL_180 BL_181 BL_182
+  BL_183 BL_184 BL_185 BL_186 BL_187 BL_188 BL_189 BL_190 BL_191 BL_192
+  BL_193 BL_194 BL_195 BL_196 BL_197 BL_198 BL_199 BL_200 BL_201 BL_202
+  BL_203 BL_204 BL_205 BL_206 BL_207 BL_208 BL_209 BL_210 BL_211 BL_212
+  BL_213 BL_214 BL_215 BL_216 BL_217 BL_218 BL_219 BL_220 BL_221 BL_222
+  BL_223 BL_224 BL_225 BL_226 BL_227 BL_228 BL_229 BL_230 BL_231 BL_232
+  BL_233 BL_234 BL_235 BL_236 BL_237 BL_238 BL_239 BL_240 BL_241 BL_242
+  BL_243 BL_244 BL_245 BL_246 BL_247 BL_248 BL_249 BL_250 BL_251 BL_252
+  BL_253 BL_254 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39
+  BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49
+  BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59
+  BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69
+  BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79
+  BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89
+  BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99
+  BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108
+  BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117
+  BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126
+  BL__127 BL__128 BL__129 BL__130 BL__131 BL__132 BL__133 BL__134 BL__135
+  BL__136 BL__137 BL__138 BL__139 BL__140 BL__141 BL__142 BL__143 BL__144
+  BL__145 BL__146 BL__147 BL__148 BL__149 BL__150 BL__151 BL__152 BL__153
+  BL__154 BL__155 BL__156 BL__157 BL__158 BL__159 BL__160 BL__161 BL__162
+  BL__163 BL__164 BL__165 BL__166 BL__167 BL__168 BL__169 BL__170 BL__171
+  BL__172 BL__173 BL__174 BL__175 BL__176 BL__177 BL__178 BL__179 BL__180
+  BL__181 BL__182 BL__183 BL__184 BL__185 BL__186 BL__187 BL__188 BL__189
+  BL__190 BL__191 BL__192 BL__193 BL__194 BL__195 BL__196 BL__197 BL__198
+  BL__199 BL__200 BL__201 BL__202 BL__203 BL__204 BL__205 BL__206 BL__207
+  BL__208 BL__209 BL__210 BL__211 BL__212 BL__213 BL__214 BL__215 BL__216
+  BL__217 BL__218 BL__219 BL__220 BL__221 BL__222 BL__223 BL__224 BL__225
+  BL__226 BL__227 BL__228 BL__229 BL__230 BL__231 BL__232 BL__233 BL__234
+  BL__235 BL__236 BL__237 BL__238 BL__239 BL__240 BL__241 BL__242 BL__243
+  BL__244 BL__245 BL__246 BL__247 BL__248 BL__249 BL__250 BL__251 BL__252
+  BL__253 BL__254 BWEN BWEN_0 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10
+  D_11 D_12 D_13 D_14 GTP GTP_0 GTP_1 OE_ Q Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW
+  STUBDW_ STUBDW_0 STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32WING_16_LEFT: 400450 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BWEN D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR_67 STUBDR__65 STUBDR_0 STUBDR__0 STUBDW_69 STUBDW__71 STUBDW_0
+  STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_ODD_RO16
XI10_0 A0 A0_ BL_126 BL__126 BL_125 BL_124 BL_123 BL_122 BL_121 BL_120 BL_119
+  BL_118 BL_117 BL_116 BL_115 BL_114 BL_113 BL_112 BL_111 BL__125 BL__124
+  BL__123 BL__122 BL__121 BL__120 BL__119 BL__118 BL__117 BL__116 BL__115
+  BL__114 BL__113 BL__112 BL__111 BWEN D_6 GTP GTP_0 GTP_1 OE_ Q_6 STUBDR_3
+  STUBDR__1 STUBDR_0_11 STUBDR__0_9 STUBDW_5 STUBDW__7 STUBDW_0_13
+  STUBDW__0_15 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_EVEN_LE16
XI12_0 A0 A0_ BL_127 BL__127 BL_128 BL_129 BL_130 BL_131 BL_132 BL_133 BL_134
+  BL_135 BL_136 BL_137 BL_138 BL_139 BL_140 BL_141 BL_142 BL__128 BL__129
+  BL__130 BL__131 BL__132 BL__133 BL__134 BL__135 BL__136 BL__137 BL__138
+  BL__139 BL__140 BL__141 BL__142 BWEN_0 D_7 GTP GTP_0 GTP_1 OE_ Q_7
+  STUBDR_19 STUBDR__17 STUBDR_0_11 STUBDR__0_9 STUBDW_21 STUBDW__23
+  STUBDW_0_13 STUBDW__0_15 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_ODD_RO16
XI13_0 A0 A0_ BL_158 BL__158 BL_157 BL_156 BL_155 BL_154 BL_153 BL_152 BL_151
+  BL_150 BL_149 BL_148 BL_147 BL_146 BL_145 BL_144 BL_143 BL__157 BL__156
+  BL__155 BL__154 BL__153 BL__152 BL__151 BL__150 BL__149 BL__148 BL__147
+  BL__146 BL__145 BL__144 BL__143 BWEN_0 D_8 GTP GTP_0 GTP_1 OE_ Q_8
+  STUBDR_19 STUBDR__17 STUBDR_0_27 STUBDR__0_25 STUBDW_21 STUBDW__23
+  STUBDW_0_29 STUBDW__0_31 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_EVEN_M16
XI15_0 A0 A0_ BL_159 BL__159 BL_160 BL_161 BL_162 BL_163 BL_164 BL_165 BL_166
+  BL_167 BL_168 BL_169 BL_170 BL_171 BL_172 BL_173 BL_174 BL__160 BL__161
+  BL__162 BL__163 BL__164 BL__165 BL__166 BL__167 BL__168 BL__169 BL__170
+  BL__171 BL__172 BL__173 BL__174 BWEN_0 D_9 GTP GTP_0 GTP_1 OE_ Q_9
+  STUBDR_35 STUBDR__33 STUBDR_0_27 STUBDR__0_25 STUBDW_37 STUBDW__39
+  STUBDW_0_29 STUBDW__0_31 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_ODD_M16
XI16_0 A0 A0_ BL_190 BL__190 BL_189 BL_188 BL_187 BL_186 BL_185 BL_184 BL_183
+  BL_182 BL_181 BL_180 BL_179 BL_178 BL_177 BL_176 BL_175 BL__189 BL__188
+  BL__187 BL__186 BL__185 BL__184 BL__183 BL__182 BL__181 BL__180 BL__179
+  BL__178 BL__177 BL__176 BL__175 BWEN_0 D_10 GTP GTP_0 GTP_1 OE_ Q_10
+  STUBDR_35 STUBDR__33 STUBDR_0_43 STUBDR__0_41 STUBDW_37 STUBDW__39
+  STUBDW_0_45 STUBDW__0_47 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_EVEN_M16
XI18_0 A0 A0_ BL_191 BL__191 BL_192 BL_193 BL_194 BL_195 BL_196 BL_197 BL_198
+  BL_199 BL_200 BL_201 BL_202 BL_203 BL_204 BL_205 BL_206 BL__192 BL__193
+  BL__194 BL__195 BL__196 BL__197 BL__198 BL__199 BL__200 BL__201 BL__202
+  BL__203 BL__204 BL__205 BL__206 BWEN_0 D_11 GTP GTP_0 GTP_1 OE_ Q_11
+  STUBDR_51 STUBDR__49 STUBDR_0_43 STUBDR__0_41 STUBDW_53 STUBDW__55
+  STUBDW_0_45 STUBDW__0_47 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_ODD_M16
XI19_0 A0 A0_ BL_222 BL__222 BL_221 BL_220 BL_219 BL_218 BL_217 BL_216 BL_215
+  BL_214 BL_213 BL_212 BL_211 BL_210 BL_209 BL_208 BL_207 BL__221 BL__220
+  BL__219 BL__218 BL__217 BL__216 BL__215 BL__214 BL__213 BL__212 BL__211
+  BL__210 BL__209 BL__208 BL__207 BWEN_0 D_12 GTP GTP_0 GTP_1 OE_ Q_12
+  STUBDR_51 STUBDR__49 STUBDR_0_59 STUBDR__0_57 STUBDW_53 STUBDW__55
+  STUBDW_0_61 STUBDW__0_63 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_EVEN_M16
XI1_0 A0 A0_ BL_30 BL__30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL_22
+  BL_21 BL_20 BL_19 BL_18 BL_17 BL_16 BL_15 BL__29 BL__28 BL__27 BL__26
+  BL__25 BL__24 BL__23 BL__22 BL__21 BL__20 BL__19 BL__18 BL__17 BL__16
+  BL__15 BWEN D_0 GTP GTP_0 GTP_1 OE_ Q_0 STUBDR_67 STUBDR__65 STUBDR_0_75
+  STUBDR__0_73 STUBDW_69 STUBDW__71 STUBDW_0_77 STUBDW__0_79 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_EVEN_M16
XI21_0 A0 A0_ BL_223 BL__223 BL_224 BL_225 BL_226 BL_227 BL_228 BL_229 BL_230
+  BL_231 BL_232 BL_233 BL_234 BL_235 BL_236 BL_237 BL_238 BL__224 BL__225
+  BL__226 BL__227 BL__228 BL__229 BL__230 BL__231 BL__232 BL__233 BL__234
+  BL__235 BL__236 BL__237 BL__238 BWEN_0 D_13 GTP GTP_0 GTP_1 OE_ Q_13
+  STUBDR_115 STUBDR__113 STUBDR_0_59 STUBDR__0_57 STUBDW_117 STUBDW__119
+  STUBDW_0_61 STUBDW__0_63 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_ODD_M16
XI22_0 A0 A0_ BL_254 BL__254 BL_253 BL_252 BL_251 BL_250 BL_249 BL_248 BL_247
+  BL_246 BL_245 BL_244 BL_243 BL_242 BL_241 BL_240 BL_239 BL__253 BL__252
+  BL__251 BL__250 BL__249 BL__248 BL__247 BL__246 BL__245 BL__244 BL__243
+  BL__242 BL__241 BL__240 BL__239 BWEN_0 D_14 GTP GTP_0 GTP_1 OE_ Q_14
+  STUBDR_115 STUBDR__113 STUBDR STUBDR_ STUBDW_117 STUBDW__119 STUBDW STUBDW_
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76
+  WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88
+  WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100
+  WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110
+  WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120
+  WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130
+  WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140
+  WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150
+  WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160
+  WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170
+  WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180
+  WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190
+  WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200
+  WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210
+  WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220
+  WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230
+  WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240
+  WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250
+  WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VSS VDD RA1SHD4096X32MCOL_EVEN_LE16
XI3_0 A0 A0_ BL_31 BL__31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39
+  BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL__32 BL__33 BL__34 BL__35
+  BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45
+  BL__46 BWEN D_1 GTP GTP_0 GTP_1 OE_ Q_1 STUBDR_83 STUBDR__81 STUBDR_0_75
+  STUBDR__0_73 STUBDW_85 STUBDW__87 STUBDW_0_77 STUBDW__0_79 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_ODD_M16
XI4_0 A0 A0_ BL_62 BL__62 BL_61 BL_60 BL_59 BL_58 BL_57 BL_56 BL_55 BL_54
+  BL_53 BL_52 BL_51 BL_50 BL_49 BL_48 BL_47 BL__61 BL__60 BL__59 BL__58
+  BL__57 BL__56 BL__55 BL__54 BL__53 BL__52 BL__51 BL__50 BL__49 BL__48
+  BL__47 BWEN D_2 GTP GTP_0 GTP_1 OE_ Q_2 STUBDR_83 STUBDR__81 STUBDR_0_91
+  STUBDR__0_89 STUBDW_85 STUBDW__87 STUBDW_0_93 STUBDW__0_95 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_EVEN_M16
XI6_0 A0 A0_ BL_63 BL__63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71
+  BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL__64 BL__65 BL__66 BL__67
+  BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77
+  BL__78 BWEN D_3 GTP GTP_0 GTP_1 OE_ Q_3 STUBDR_99 STUBDR__97 STUBDR_0_91
+  STUBDR__0_89 STUBDW_101 STUBDW__103 STUBDW_0_93 STUBDW__0_95 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_ODD_M16
XI7_0 A0 A0_ BL_94 BL__94 BL_93 BL_92 BL_91 BL_90 BL_89 BL_88 BL_87 BL_86
+  BL_85 BL_84 BL_83 BL_82 BL_81 BL_80 BL_79 BL__93 BL__92 BL__91 BL__90
+  BL__89 BL__88 BL__87 BL__86 BL__85 BL__84 BL__83 BL__82 BL__81 BL__80
+  BL__79 BWEN D_4 GTP GTP_0 GTP_1 OE_ Q_4 STUBDR_99 STUBDR__97 STUBDR_0_107
+  STUBDR__0_105 STUBDW_101 STUBDW__103 STUBDW_0_109 STUBDW__0_111 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_EVEN_M16
XI9_0 A0 A0_ BL_95 BL__95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BWEN D_5 GTP GTP_0 GTP_1 OE_ Q_5 STUBDR_3 STUBDR__1
+  STUBDR_0_107 STUBDR__0_105 STUBDW_5 STUBDW__7 STUBDW_0_109 STUBDW__0_111 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73
+  WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85
+  WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97
+  WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108
+  WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118
+  WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128
+  WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138
+  WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148
+  WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158
+  WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168
+  WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178
+  WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188
+  WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198
+  WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208
+  WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218
+  WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228
+  WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238
+  WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248
+  WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66
+  WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78
+  WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90
+  WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102
+  WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112
+  WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122
+  WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132
+  WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142
+  WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152
+  WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162
+  WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172
+  WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182
+  WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192
+  WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202
+  WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212
+  WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222
+  WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232
+  WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242
+  WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252
+  WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_ODD_M16
.ENDS RA1SHD4096X32WING_16_LEFT
****
.SUBCKT RA1SHD4096X32HXP24 A0 A1 ACONN0 ACONN1 AGTPB AGTPT AMX0 AMX1 AY0 AY0_
+  BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** RA1SHD4096X32HXP24: 100 flat devices **
d15 VSS A1 DN 0.3364P 2.32U
d16 VSS BWEN DN 0.3364P 2.32U
d7 VSS A0 DN 0.3364P 2.32U
d8 VSS BWEN DN 0.3364P 2.32U
m1 N29 N36 VDD VDD P L=0.18U W=8.16U
m10 N33 N45 VSS VSS N L=0.18U W=4U
m100 XP_3 AP_I6-APN0 VSS VSS N L=0.18U W=15.13U
m11 N32 ACONN1 VDD VDD P L=0.18U W=8.16U
m12 N32 ACONN1 VSS VSS N L=0.18U W=4.02U
m13 N45 ACONN1 VDD VDD P L=0.18U W=6.52U
m14 N45 ACONN1 VSS VSS N L=0.18U W=3.2U
m17 AP_I5-APN1 N62 AP_I5-AIND1 VSS N L=0.18U W=6.24U
m18 AP_I5-APN1 AGTPT AP_I5-AIND1 VDD P L=0.18U W=10.66U
m19 N62 AGTPT VDD VDD P L=0.18U W=1.48U
m2 N29 N36 VSS VSS N L=0.18U W=4U
m20 N62 AGTPT VSS VSS N L=0.18U W=0.94U
m21 AP_I5-AIN21 N29 VDD VDD P L=0.18U W=5.94U
m22 AP_I5-AIN21 N29 VSS VSS N L=0.18U W=2.87U
m23 N56 N33 VDD VDD P L=0.18U W=5.94U
m24 N56 N33 VSS VSS N L=0.18U W=2.87U
m25 N57 VSS VDD VDD P L=0.18U W=5.94U
m26 N57 VSS VSS VSS N L=0.18U W=2.87U
m27 N91 N57 VSS VSS N L=0.18U W=6.24U
m28 N90 N56 N91 VSS N L=0.18U W=6.24U
m29 AP_I5-AIND1 AP_I5-AIN21 N90 VSS N L=0.18U W=6.24U
m3 N28 ACONN0 VDD VDD P L=0.18U W=8.16U
m30 AP_I5-AIND1 N57 VDD VDD P L=0.18U W=10.66U
m31 N89 N57 VSS VSS N L=0.18U W=6.24U
m32 AP_I5-AIND1 N56 VDD VDD P L=0.18U W=10.66U
m33 N88 N56 N89 VSS N L=0.18U W=6.24U
m34 AP_I5-AIND1 AP_I5-AIN21 VDD VDD P L=0.18U W=10.66U
m35 AP_I5-AIND1 AP_I5-AIN21 N88 VSS N L=0.18U W=6.24U
m36 AP_I5-APN0 N73 AP_I5-AIND0 VSS N L=0.18U W=6.24U
m37 AP_I5-APN0 AGTPB AP_I5-AIND0 VDD P L=0.18U W=10.66U
m38 N73 AGTPB VDD VDD P L=0.18U W=1.48U
m39 N73 AGTPB VSS VSS N L=0.18U W=0.94U
m4 N28 ACONN0 VSS VSS N L=0.18U W=4.02U
m40 AP_I5-AIN20 N28 VDD VDD P L=0.18U W=5.94U
m41 AP_I5-AIN20 N28 VSS VSS N L=0.18U W=2.87U
m42 N95 N57 VSS VSS N L=0.18U W=6.24U
m43 N94 N56 N95 VSS N L=0.18U W=6.24U
m44 AP_I5-AIND0 AP_I5-AIN20 N94 VSS N L=0.18U W=6.24U
m45 AP_I5-AIND0 N57 VDD VDD P L=0.18U W=10.66U
m46 N93 N57 VSS VSS N L=0.18U W=6.24U
m47 AP_I5-AIND0 N56 VDD VDD P L=0.18U W=10.66U
m48 N92 N56 N93 VSS N L=0.18U W=6.24U
m49 AP_I5-AIND0 AP_I5-AIN20 VDD VDD P L=0.18U W=10.66U
m5 N36 ACONN0 VDD VDD P L=0.18U W=6.52U
m50 AP_I5-AIND0 AP_I5-AIN20 N92 VSS N L=0.18U W=6.24U
m51 AP_I5-APN1 XP_0 VDD VDD P L=0.27U W=0.22U
m52 AP_I5-APN1 XP_0 VSS VSS N L=0.54U W=0.22U
m53 XP_0 AP_I5-APN1 VDD VDD P L=0.18U W=28.56U
m54 XP_0 AP_I5-APN1 VSS VSS N L=0.18U W=15.13U
m55 AP_I5-APN0 XP_1 VDD VDD P L=0.27U W=0.22U
m56 AP_I5-APN0 XP_1 VSS VSS N L=0.54U W=0.22U
m57 XP_1 AP_I5-APN0 VDD VDD P L=0.18U W=28.56U
m58 XP_1 AP_I5-APN0 VSS VSS N L=0.18U W=15.13U
m59 AP_I6-APN1 N104 AP_I6-AIND1 VSS N L=0.18U W=6.24U
m6 N36 ACONN0 VSS VSS N L=0.18U W=3.2U
m60 AP_I6-APN1 AGTPT AP_I6-AIND1 VDD P L=0.18U W=10.66U
m61 N104 AGTPT VDD VDD P L=0.18U W=1.48U
m62 N104 AGTPT VSS VSS N L=0.18U W=0.94U
m63 AP_I6-AIN21 N29 VDD VDD P L=0.18U W=5.94U
m64 AP_I6-AIN21 N29 VSS VSS N L=0.18U W=2.87U
m65 N98 N32 VDD VDD P L=0.18U W=5.94U
m66 N98 N32 VSS VSS N L=0.18U W=2.87U
m67 N99 VSS VDD VDD P L=0.18U W=5.94U
m68 N99 VSS VSS VSS N L=0.18U W=2.87U
m69 N133 N99 VSS VSS N L=0.18U W=6.24U
m70 N132 N98 N133 VSS N L=0.18U W=6.24U
m71 AP_I6-AIND1 AP_I6-AIN21 N132 VSS N L=0.18U W=6.24U
m72 AP_I6-AIND1 N99 VDD VDD P L=0.18U W=10.66U
m73 N131 N99 VSS VSS N L=0.18U W=6.24U
m74 AP_I6-AIND1 N98 VDD VDD P L=0.18U W=10.66U
m75 N130 N98 N131 VSS N L=0.18U W=6.24U
m76 AP_I6-AIND1 AP_I6-AIN21 VDD VDD P L=0.18U W=10.66U
m77 AP_I6-AIND1 AP_I6-AIN21 N130 VSS N L=0.18U W=6.24U
m78 AP_I6-APN0 N115 AP_I6-AIND0 VSS N L=0.18U W=6.24U
m79 AP_I6-APN0 AGTPB AP_I6-AIND0 VDD P L=0.18U W=10.66U
m80 N115 AGTPB VDD VDD P L=0.18U W=1.48U
m81 N115 AGTPB VSS VSS N L=0.18U W=0.94U
m82 AP_I6-AIN20 N28 VDD VDD P L=0.18U W=5.94U
m83 AP_I6-AIN20 N28 VSS VSS N L=0.18U W=2.87U
m84 N137 N99 VSS VSS N L=0.18U W=6.24U
m85 N136 N98 N137 VSS N L=0.18U W=6.24U
m86 AP_I6-AIND0 AP_I6-AIN20 N136 VSS N L=0.18U W=6.24U
m87 AP_I6-AIND0 N99 VDD VDD P L=0.18U W=10.66U
m88 N135 N99 VSS VSS N L=0.18U W=6.24U
m89 AP_I6-AIND0 N98 VDD VDD P L=0.18U W=10.66U
m9 N33 N45 VDD VDD P L=0.18U W=8.16U
m90 N134 N98 N135 VSS N L=0.18U W=6.24U
m91 AP_I6-AIND0 AP_I6-AIN20 VDD VDD P L=0.18U W=10.66U
m92 AP_I6-AIND0 AP_I6-AIN20 N134 VSS N L=0.18U W=6.24U
m93 AP_I6-APN1 XP_2 VDD VDD P L=0.27U W=0.22U
m94 AP_I6-APN1 XP_2 VSS VSS N L=0.54U W=0.22U
m95 XP_2 AP_I6-APN1 VDD VDD P L=0.18U W=28.56U
m96 XP_2 AP_I6-APN1 VSS VSS N L=0.18U W=15.13U
m97 AP_I6-APN0 XP_3 VDD VDD P L=0.27U W=0.22U
m98 AP_I6-APN0 XP_3 VSS VSS N L=0.54U W=0.22U
m99 XP_3 AP_I6-APN0 VDD VDD P L=0.18U W=28.56U
.ENDS RA1SHD4096X32HXP24
****
.SUBCKT RA1SHD4096X32HXP24X A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1
+  XP_2 XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32HXP24X: 100 flat devices **
XI0_0 A0 A1 A0 A1 AGTPB AGTPT VSS VSS AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2
+  XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32HXP24
.ENDS RA1SHD4096X32HXP24X
****
.SUBCKT RA1SHD4096X32HXP38 A0 A1 A2 ACONN0 ACONN1 ACONN2 AGTPB AGTPT AMX0 AMX1
+  AMX2 AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32HXP38: 192 flat devices **
d175 VSS A2 DN 0.3364P 2.32U
d176 VSS BWEN DN 0.3364P 2.32U
d183 VSS A1 DN 0.3364P 2.32U
d184 VSS BWEN DN 0.3364P 2.32U
d191 VSS A0 DN 0.3364P 2.32U
d192 VSS BWEN DN 0.3364P 2.32U
m1 AP67-APN1 N54 AP67-AIND1 VSS N L=0.18U W=6.24U
m10 N49 AI2_ VSS VSS N L=0.18U W=2.87U
m100 AP23-AIND1 N132 VDD VDD P L=0.18U W=10.66U
m101 N164 N132 N165 VSS N L=0.18U W=6.24U
m102 AP23-AIND1 AP23-AIN21 VDD VDD P L=0.18U W=10.66U
m103 AP23-AIND1 AP23-AIN21 N164 VSS N L=0.18U W=6.24U
m104 AP23-APN0 N149 AP23-AIND0 VSS N L=0.18U W=6.24U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD P L=0.18U W=10.66U
m106 N149 AGTPB VDD VDD P L=0.18U W=1.48U
m107 N149 AGTPB VSS VSS N L=0.18U W=0.94U
m108 AP23-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m109 AP23-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m11 N83 N49 VSS VSS N L=0.18U W=6.24U
m110 N171 N133 VSS VSS N L=0.18U W=6.24U
m111 N170 N132 N171 VSS N L=0.18U W=6.24U
m112 AP23-AIND0 AP23-AIN20 N170 VSS N L=0.18U W=6.24U
m113 AP23-AIND0 N133 VDD VDD P L=0.18U W=10.66U
m114 N169 N133 VSS VSS N L=0.18U W=6.24U
m115 AP23-AIND0 N132 VDD VDD P L=0.18U W=10.66U
m116 N168 N132 N169 VSS N L=0.18U W=6.24U
m117 AP23-AIND0 AP23-AIN20 VDD VDD P L=0.18U W=10.66U
m118 AP23-AIND0 AP23-AIN20 N168 VSS N L=0.18U W=6.24U
m119 AP23-APN1 XP_3 VDD VDD P L=0.27U W=0.22U
m12 N82 N48 N83 VSS N L=0.18U W=6.24U
m120 AP23-APN1 XP_3 VSS VSS N L=0.54U W=0.22U
m121 XP_3 AP23-APN1 VDD VDD P L=0.18U W=28.56U
m122 XP_3 AP23-APN1 VSS VSS N L=0.18U W=15.13U
m123 AP23-APN0 XP_2 VDD VDD P L=0.27U W=0.22U
m124 AP23-APN0 XP_2 VSS VSS N L=0.54U W=0.22U
m125 XP_2 AP23-APN0 VDD VDD P L=0.18U W=28.56U
m126 XP_2 AP23-APN0 VSS VSS N L=0.18U W=15.13U
m127 AP01-APN1 N180 AP01-AIND1 VSS N L=0.18U W=6.24U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD P L=0.18U W=10.66U
m129 N180 AGTPT VDD VDD P L=0.18U W=1.48U
m13 AP67-AIND1 AP67-AIN21 N82 VSS N L=0.18U W=6.24U
m130 N180 AGTPT VSS VSS N L=0.18U W=0.94U
m131 AP01-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m132 AP01-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m133 N174 AI1 VDD VDD P L=0.18U W=5.94U
m134 N174 AI1 VSS VSS N L=0.18U W=2.87U
m135 N175 AI2 VDD VDD P L=0.18U W=5.94U
m136 N175 AI2 VSS VSS N L=0.18U W=2.87U
m137 N209 N175 VSS VSS N L=0.18U W=6.24U
m138 N208 N174 N209 VSS N L=0.18U W=6.24U
m139 AP01-AIND1 AP01-AIN21 N208 VSS N L=0.18U W=6.24U
m14 AP67-AIND1 N49 VDD VDD P L=0.18U W=10.66U
m140 AP01-AIND1 N175 VDD VDD P L=0.18U W=10.66U
m141 N207 N175 VSS VSS N L=0.18U W=6.24U
m142 AP01-AIND1 N174 VDD VDD P L=0.18U W=10.66U
m143 N206 N174 N207 VSS N L=0.18U W=6.24U
m144 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.18U W=10.66U
m145 AP01-AIND1 AP01-AIN21 N206 VSS N L=0.18U W=6.24U
m146 AP01-APN0 N191 AP01-AIND0 VSS N L=0.18U W=6.24U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD P L=0.18U W=10.66U
m148 N191 AGTPB VDD VDD P L=0.18U W=1.48U
m149 N191 AGTPB VSS VSS N L=0.18U W=0.94U
m15 N81 N49 VSS VSS N L=0.18U W=6.24U
m150 AP01-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m151 AP01-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m152 N213 N175 VSS VSS N L=0.18U W=6.24U
m153 N212 N174 N213 VSS N L=0.18U W=6.24U
m154 AP01-AIND0 AP01-AIN20 N212 VSS N L=0.18U W=6.24U
m155 AP01-AIND0 N175 VDD VDD P L=0.18U W=10.66U
m156 N211 N175 VSS VSS N L=0.18U W=6.24U
m157 AP01-AIND0 N174 VDD VDD P L=0.18U W=10.66U
m158 N210 N174 N211 VSS N L=0.18U W=6.24U
m159 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.18U W=10.66U
m16 AP67-AIND1 N48 VDD VDD P L=0.18U W=10.66U
m160 AP01-AIND0 AP01-AIN20 N210 VSS N L=0.18U W=6.24U
m161 AP01-APN1 XP_1 VDD VDD P L=0.27U W=0.22U
m162 AP01-APN1 XP_1 VSS VSS N L=0.54U W=0.22U
m163 XP_1 AP01-APN1 VDD VDD P L=0.18U W=28.56U
m164 XP_1 AP01-APN1 VSS VSS N L=0.18U W=15.13U
m165 AP01-APN0 XP_0 VDD VDD P L=0.27U W=0.22U
m166 AP01-APN0 XP_0 VSS VSS N L=0.54U W=0.22U
m167 XP_0 AP01-APN0 VDD VDD P L=0.18U W=28.56U
m168 XP_0 AP01-APN0 VSS VSS N L=0.18U W=15.13U
m169 AI2 N214 VDD VDD P L=0.18U W=8.16U
m17 N80 N48 N81 VSS N L=0.18U W=6.24U
m170 AI2 N214 VSS VSS N L=0.18U W=4U
m171 AI2_ ACONN2 VDD VDD P L=0.18U W=8.16U
m172 AI2_ ACONN2 VSS VSS N L=0.18U W=4.02U
m173 N214 ACONN2 VDD VDD P L=0.18U W=6.52U
m174 N214 ACONN2 VSS VSS N L=0.18U W=3.2U
m177 AI1 N223 VDD VDD P L=0.18U W=8.16U
m178 AI1 N223 VSS VSS N L=0.18U W=4U
m179 AI1_ ACONN1 VDD VDD P L=0.18U W=8.16U
m18 AP67-AIND1 AP67-AIN21 VDD VDD P L=0.18U W=10.66U
m180 AI1_ ACONN1 VSS VSS N L=0.18U W=4.02U
m181 N223 ACONN1 VDD VDD P L=0.18U W=6.52U
m182 N223 ACONN1 VSS VSS N L=0.18U W=3.2U
m185 AI0 N232 VDD VDD P L=0.18U W=8.16U
m186 AI0 N232 VSS VSS N L=0.18U W=4U
m187 AI0_ ACONN0 VDD VDD P L=0.18U W=8.16U
m188 AI0_ ACONN0 VSS VSS N L=0.18U W=4.02U
m189 N232 ACONN0 VDD VDD P L=0.18U W=6.52U
m19 AP67-AIND1 AP67-AIN21 N80 VSS N L=0.18U W=6.24U
m190 N232 ACONN0 VSS VSS N L=0.18U W=3.2U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD P L=0.18U W=10.66U
m20 AP67-APN0 N65 AP67-AIND0 VSS N L=0.18U W=6.24U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD P L=0.18U W=10.66U
m22 N65 AGTPB VDD VDD P L=0.18U W=1.48U
m23 N65 AGTPB VSS VSS N L=0.18U W=0.94U
m24 AP67-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m25 AP67-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m26 N87 N49 VSS VSS N L=0.18U W=6.24U
m27 N86 N48 N87 VSS N L=0.18U W=6.24U
m28 AP67-AIND0 AP67-AIN20 N86 VSS N L=0.18U W=6.24U
m29 AP67-AIND0 N49 VDD VDD P L=0.18U W=10.66U
m3 N54 AGTPT VDD VDD P L=0.18U W=1.48U
m30 N85 N49 VSS VSS N L=0.18U W=6.24U
m31 AP67-AIND0 N48 VDD VDD P L=0.18U W=10.66U
m32 N84 N48 N85 VSS N L=0.18U W=6.24U
m33 AP67-AIND0 AP67-AIN20 VDD VDD P L=0.18U W=10.66U
m34 AP67-AIND0 AP67-AIN20 N84 VSS N L=0.18U W=6.24U
m35 AP67-APN1 XP_7 VDD VDD P L=0.27U W=0.22U
m36 AP67-APN1 XP_7 VSS VSS N L=0.54U W=0.22U
m37 XP_7 AP67-APN1 VDD VDD P L=0.18U W=28.56U
m38 XP_7 AP67-APN1 VSS VSS N L=0.18U W=15.13U
m39 AP67-APN0 XP_6 VDD VDD P L=0.27U W=0.22U
m4 N54 AGTPT VSS VSS N L=0.18U W=0.94U
m40 AP67-APN0 XP_6 VSS VSS N L=0.54U W=0.22U
m41 XP_6 AP67-APN0 VDD VDD P L=0.18U W=28.56U
m42 XP_6 AP67-APN0 VSS VSS N L=0.18U W=15.13U
m43 AP45-APN1 N96 AP45-AIND1 VSS N L=0.18U W=6.24U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD P L=0.18U W=10.66U
m45 N96 AGTPT VDD VDD P L=0.18U W=1.48U
m46 N96 AGTPT VSS VSS N L=0.18U W=0.94U
m47 AP45-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m48 AP45-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m49 N90 AI1 VDD VDD P L=0.18U W=5.94U
m5 AP67-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m50 N90 AI1 VSS VSS N L=0.18U W=2.87U
m51 N91 AI2_ VDD VDD P L=0.18U W=5.94U
m52 N91 AI2_ VSS VSS N L=0.18U W=2.87U
m53 N125 N91 VSS VSS N L=0.18U W=6.24U
m54 N124 N90 N125 VSS N L=0.18U W=6.24U
m55 AP45-AIND1 AP45-AIN21 N124 VSS N L=0.18U W=6.24U
m56 AP45-AIND1 N91 VDD VDD P L=0.18U W=10.66U
m57 N123 N91 VSS VSS N L=0.18U W=6.24U
m58 AP45-AIND1 N90 VDD VDD P L=0.18U W=10.66U
m59 N122 N90 N123 VSS N L=0.18U W=6.24U
m6 AP67-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m60 AP45-AIND1 AP45-AIN21 VDD VDD P L=0.18U W=10.66U
m61 AP45-AIND1 AP45-AIN21 N122 VSS N L=0.18U W=6.24U
m62 AP45-APN0 N107 AP45-AIND0 VSS N L=0.18U W=6.24U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD P L=0.18U W=10.66U
m64 N107 AGTPB VDD VDD P L=0.18U W=1.48U
m65 N107 AGTPB VSS VSS N L=0.18U W=0.94U
m66 AP45-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m67 AP45-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m68 N129 N91 VSS VSS N L=0.18U W=6.24U
m69 N128 N90 N129 VSS N L=0.18U W=6.24U
m7 N48 AI1_ VDD VDD P L=0.18U W=5.94U
m70 AP45-AIND0 AP45-AIN20 N128 VSS N L=0.18U W=6.24U
m71 AP45-AIND0 N91 VDD VDD P L=0.18U W=10.66U
m72 N127 N91 VSS VSS N L=0.18U W=6.24U
m73 AP45-AIND0 N90 VDD VDD P L=0.18U W=10.66U
m74 N126 N90 N127 VSS N L=0.18U W=6.24U
m75 AP45-AIND0 AP45-AIN20 VDD VDD P L=0.18U W=10.66U
m76 AP45-AIND0 AP45-AIN20 N126 VSS N L=0.18U W=6.24U
m77 AP45-APN1 XP_5 VDD VDD P L=0.27U W=0.22U
m78 AP45-APN1 XP_5 VSS VSS N L=0.54U W=0.22U
m79 XP_5 AP45-APN1 VDD VDD P L=0.18U W=28.56U
m8 N48 AI1_ VSS VSS N L=0.18U W=2.87U
m80 XP_5 AP45-APN1 VSS VSS N L=0.18U W=15.13U
m81 AP45-APN0 XP_4 VDD VDD P L=0.27U W=0.22U
m82 AP45-APN0 XP_4 VSS VSS N L=0.54U W=0.22U
m83 XP_4 AP45-APN0 VDD VDD P L=0.18U W=28.56U
m84 XP_4 AP45-APN0 VSS VSS N L=0.18U W=15.13U
m85 AP23-APN1 N138 AP23-AIND1 VSS N L=0.18U W=6.24U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD P L=0.18U W=10.66U
m87 N138 AGTPT VDD VDD P L=0.18U W=1.48U
m88 N138 AGTPT VSS VSS N L=0.18U W=0.94U
m89 AP23-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m9 N49 AI2_ VDD VDD P L=0.18U W=5.94U
m90 AP23-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m91 N132 AI1_ VDD VDD P L=0.18U W=5.94U
m92 N132 AI1_ VSS VSS N L=0.18U W=2.87U
m93 N133 AI2 VDD VDD P L=0.18U W=5.94U
m94 N133 AI2 VSS VSS N L=0.18U W=2.87U
m95 N167 N133 VSS VSS N L=0.18U W=6.24U
m96 N166 N132 N167 VSS N L=0.18U W=6.24U
m97 AP23-AIND1 AP23-AIN21 N166 VSS N L=0.18U W=6.24U
m98 AP23-AIND1 N133 VDD VDD P L=0.18U W=10.66U
m99 N165 N133 VSS VSS N L=0.18U W=6.24U
.ENDS RA1SHD4096X32HXP38
****
.SUBCKT RA1SHD4096X32HXP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0
+  XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32HXP38X: 192 flat devices **
XI0_0 A0 A1 A2 A0 A1 A2 AGTPB AGTPT VSS VSS VSS AY0 AY0_ BWEN OEI_ WEI XP_0
+  XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD4096X32HXP38
.ENDS RA1SHD4096X32HXP38X
****
.SUBCKT RA1SHD4096X32X_PRE_DECODE A0 A0_0 A0_1 A1 A1_0 A1_1 A2 A2_0 AGTPB
+  AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_0_0 XP_0_1 XP_1 XP_1_0 XP_1_1 XP_2
+  XP_2_0 XP_2_1 XP_3 XP_3_0 XP_3_1 XP_4 XP_4_0 XP_5 XP_5_0 XP_6 XP_6_0 XP_7
+  XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32X_PRE_DECODE: 484 flat devices **
XI0_0 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32HXP24X
XI1_0 A0_0 A1_0 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_0 XP_1_0 XP_2_0
+  XP_3_0 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VSS VDD RA1SHD4096X32HXP38X
XI2_0 A0_1 A1_1 A2_0 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_1 XP_1_1 XP_2_1
+  XP_3_1 XP_4_0 XP_5_0 XP_6_0 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD4096X32HXP38X
.ENDS RA1SHD4096X32X_PRE_DECODE
****
.SUBCKT RA1SHD4096X32HYP38 A0 A1 A2 ACONN0 ACONN1 ACONN2 AGTPB AGTPT AMX0 AMX1
+  AMX2 AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VSS VDD
** RA1SHD4096X32HYP38: 192 flat devices **
d175 VSS A2 DN 0.3364P 2.32U
d176 VSS BWEN DN 0.3364P 2.32U
d183 VSS A1 DN 0.3364P 2.32U
d184 VSS BWEN DN 0.3364P 2.32U
d191 VSS A0 DN 0.3364P 2.32U
d192 VSS BWEN DN 0.3364P 2.32U
m1 AP67-APN1 N46 AP67-AIND1 VSS N L=0.18U W=6.24U
m10 N41 AI2_ VSS VSS N L=0.18U W=2.87U
m100 AP23-AIND1 N124 VDD VDD P L=0.18U W=10.66U
m101 N156 N124 N157 VSS N L=0.18U W=6.24U
m102 AP23-AIND1 AP23-AIN21 VDD VDD P L=0.18U W=10.66U
m103 AP23-AIND1 AP23-AIN21 N156 VSS N L=0.18U W=6.24U
m104 AP23-APN0 N141 AP23-AIND0 VSS N L=0.18U W=6.24U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD P L=0.18U W=10.66U
m106 N141 AGTPB VDD VDD P L=0.18U W=1.48U
m107 N141 AGTPB VSS VSS N L=0.18U W=0.94U
m108 AP23-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m109 AP23-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m11 N75 N41 VSS VSS N L=0.18U W=6.24U
m110 N163 N125 VSS VSS N L=0.18U W=6.24U
m111 N162 N124 N163 VSS N L=0.18U W=6.24U
m112 AP23-AIND0 AP23-AIN20 N162 VSS N L=0.18U W=6.24U
m113 AP23-AIND0 N125 VDD VDD P L=0.18U W=10.66U
m114 N161 N125 VSS VSS N L=0.18U W=6.24U
m115 AP23-AIND0 N124 VDD VDD P L=0.18U W=10.66U
m116 N160 N124 N161 VSS N L=0.18U W=6.24U
m117 AP23-AIND0 AP23-AIN20 VDD VDD P L=0.18U W=10.66U
m118 AP23-AIND0 AP23-AIN20 N160 VSS N L=0.18U W=6.24U
m119 AP23-APN1 YP0_3 VDD VDD P L=0.27U W=0.22U
m12 N74 N40 N75 VSS N L=0.18U W=6.24U
m120 AP23-APN1 YP0_3 VSS VSS N L=0.54U W=0.22U
m121 YP0_3 AP23-APN1 VDD VDD P L=0.18U W=28.56U
m122 YP0_3 AP23-APN1 VSS VSS N L=0.18U W=15.13U
m123 AP23-APN0 YP0_2 VDD VDD P L=0.27U W=0.22U
m124 AP23-APN0 YP0_2 VSS VSS N L=0.54U W=0.22U
m125 YP0_2 AP23-APN0 VDD VDD P L=0.18U W=28.56U
m126 YP0_2 AP23-APN0 VSS VSS N L=0.18U W=15.13U
m127 AP01-APN1 N172 AP01-AIND1 VSS N L=0.18U W=6.24U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD P L=0.18U W=10.66U
m129 N172 AGTPT VDD VDD P L=0.18U W=1.48U
m13 AP67-AIND1 AP67-AIN21 N74 VSS N L=0.18U W=6.24U
m130 N172 AGTPT VSS VSS N L=0.18U W=0.94U
m131 AP01-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m132 AP01-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m133 N166 AI1 VDD VDD P L=0.18U W=5.94U
m134 N166 AI1 VSS VSS N L=0.18U W=2.87U
m135 N167 AI2 VDD VDD P L=0.18U W=5.94U
m136 N167 AI2 VSS VSS N L=0.18U W=2.87U
m137 N201 N167 VSS VSS N L=0.18U W=6.24U
m138 N200 N166 N201 VSS N L=0.18U W=6.24U
m139 AP01-AIND1 AP01-AIN21 N200 VSS N L=0.18U W=6.24U
m14 AP67-AIND1 N41 VDD VDD P L=0.18U W=10.66U
m140 AP01-AIND1 N167 VDD VDD P L=0.18U W=10.66U
m141 N199 N167 VSS VSS N L=0.18U W=6.24U
m142 AP01-AIND1 N166 VDD VDD P L=0.18U W=10.66U
m143 N198 N166 N199 VSS N L=0.18U W=6.24U
m144 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.18U W=10.66U
m145 AP01-AIND1 AP01-AIN21 N198 VSS N L=0.18U W=6.24U
m146 AP01-APN0 N183 AP01-AIND0 VSS N L=0.18U W=6.24U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD P L=0.18U W=10.66U
m148 N183 AGTPB VDD VDD P L=0.18U W=1.48U
m149 N183 AGTPB VSS VSS N L=0.18U W=0.94U
m15 N73 N41 VSS VSS N L=0.18U W=6.24U
m150 AP01-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m151 AP01-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m152 N205 N167 VSS VSS N L=0.18U W=6.24U
m153 N204 N166 N205 VSS N L=0.18U W=6.24U
m154 AP01-AIND0 AP01-AIN20 N204 VSS N L=0.18U W=6.24U
m155 AP01-AIND0 N167 VDD VDD P L=0.18U W=10.66U
m156 N203 N167 VSS VSS N L=0.18U W=6.24U
m157 AP01-AIND0 N166 VDD VDD P L=0.18U W=10.66U
m158 N202 N166 N203 VSS N L=0.18U W=6.24U
m159 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.18U W=10.66U
m16 AP67-AIND1 N40 VDD VDD P L=0.18U W=10.66U
m160 AP01-AIND0 AP01-AIN20 N202 VSS N L=0.18U W=6.24U
m161 AP01-APN1 YP0_1 VDD VDD P L=0.27U W=0.22U
m162 AP01-APN1 YP0_1 VSS VSS N L=0.54U W=0.22U
m163 YP0_1 AP01-APN1 VDD VDD P L=0.18U W=28.56U
m164 YP0_1 AP01-APN1 VSS VSS N L=0.18U W=15.13U
m165 AP01-APN0 YP0_0 VDD VDD P L=0.27U W=0.22U
m166 AP01-APN0 YP0_0 VSS VSS N L=0.54U W=0.22U
m167 YP0_0 AP01-APN0 VDD VDD P L=0.18U W=28.56U
m168 YP0_0 AP01-APN0 VSS VSS N L=0.18U W=15.13U
m169 AI2 N206 VDD VDD P L=0.18U W=8.16U
m17 N72 N40 N73 VSS N L=0.18U W=6.24U
m170 AI2 N206 VSS VSS N L=0.18U W=4U
m171 AI2_ ACONN2 VDD VDD P L=0.18U W=8.16U
m172 AI2_ ACONN2 VSS VSS N L=0.18U W=4.02U
m173 N206 ACONN2 VDD VDD P L=0.18U W=6.52U
m174 N206 ACONN2 VSS VSS N L=0.18U W=3.2U
m177 AI1 N215 VDD VDD P L=0.18U W=8.16U
m178 AI1 N215 VSS VSS N L=0.18U W=4U
m179 AI1_ ACONN1 VDD VDD P L=0.18U W=8.16U
m18 AP67-AIND1 AP67-AIN21 VDD VDD P L=0.18U W=10.66U
m180 AI1_ ACONN1 VSS VSS N L=0.18U W=4.02U
m181 N215 ACONN1 VDD VDD P L=0.18U W=6.52U
m182 N215 ACONN1 VSS VSS N L=0.18U W=3.2U
m185 AI0 N224 VDD VDD P L=0.18U W=8.16U
m186 AI0 N224 VSS VSS N L=0.18U W=4U
m187 AI0_ ACONN0 VDD VDD P L=0.18U W=8.16U
m188 AI0_ ACONN0 VSS VSS N L=0.18U W=4.02U
m189 N224 ACONN0 VDD VDD P L=0.18U W=6.52U
m19 AP67-AIND1 AP67-AIN21 N72 VSS N L=0.18U W=6.24U
m190 N224 ACONN0 VSS VSS N L=0.18U W=3.2U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD P L=0.18U W=10.66U
m20 AP67-APN0 N57 AP67-AIND0 VSS N L=0.18U W=6.24U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD P L=0.18U W=10.66U
m22 N57 AGTPB VDD VDD P L=0.18U W=1.48U
m23 N57 AGTPB VSS VSS N L=0.18U W=0.94U
m24 AP67-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m25 AP67-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m26 N79 N41 VSS VSS N L=0.18U W=6.24U
m27 N78 N40 N79 VSS N L=0.18U W=6.24U
m28 AP67-AIND0 AP67-AIN20 N78 VSS N L=0.18U W=6.24U
m29 AP67-AIND0 N41 VDD VDD P L=0.18U W=10.66U
m3 N46 AGTPT VDD VDD P L=0.18U W=1.48U
m30 N77 N41 VSS VSS N L=0.18U W=6.24U
m31 AP67-AIND0 N40 VDD VDD P L=0.18U W=10.66U
m32 N76 N40 N77 VSS N L=0.18U W=6.24U
m33 AP67-AIND0 AP67-AIN20 VDD VDD P L=0.18U W=10.66U
m34 AP67-AIND0 AP67-AIN20 N76 VSS N L=0.18U W=6.24U
m35 AP67-APN1 YP1_3 VDD VDD P L=0.27U W=0.22U
m36 AP67-APN1 YP1_3 VSS VSS N L=0.54U W=0.22U
m37 YP1_3 AP67-APN1 VDD VDD P L=0.18U W=28.56U
m38 YP1_3 AP67-APN1 VSS VSS N L=0.18U W=15.13U
m39 AP67-APN0 YP1_2 VDD VDD P L=0.27U W=0.22U
m4 N46 AGTPT VSS VSS N L=0.18U W=0.94U
m40 AP67-APN0 YP1_2 VSS VSS N L=0.54U W=0.22U
m41 YP1_2 AP67-APN0 VDD VDD P L=0.18U W=28.56U
m42 YP1_2 AP67-APN0 VSS VSS N L=0.18U W=15.13U
m43 AP45-APN1 N88 AP45-AIND1 VSS N L=0.18U W=6.24U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD P L=0.18U W=10.66U
m45 N88 AGTPT VDD VDD P L=0.18U W=1.48U
m46 N88 AGTPT VSS VSS N L=0.18U W=0.94U
m47 AP45-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m48 AP45-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m49 N82 AI1 VDD VDD P L=0.18U W=5.94U
m5 AP67-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m50 N82 AI1 VSS VSS N L=0.18U W=2.87U
m51 N83 AI2_ VDD VDD P L=0.18U W=5.94U
m52 N83 AI2_ VSS VSS N L=0.18U W=2.87U
m53 N117 N83 VSS VSS N L=0.18U W=6.24U
m54 N116 N82 N117 VSS N L=0.18U W=6.24U
m55 AP45-AIND1 AP45-AIN21 N116 VSS N L=0.18U W=6.24U
m56 AP45-AIND1 N83 VDD VDD P L=0.18U W=10.66U
m57 N115 N83 VSS VSS N L=0.18U W=6.24U
m58 AP45-AIND1 N82 VDD VDD P L=0.18U W=10.66U
m59 N114 N82 N115 VSS N L=0.18U W=6.24U
m6 AP67-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m60 AP45-AIND1 AP45-AIN21 VDD VDD P L=0.18U W=10.66U
m61 AP45-AIND1 AP45-AIN21 N114 VSS N L=0.18U W=6.24U
m62 AP45-APN0 N99 AP45-AIND0 VSS N L=0.18U W=6.24U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD P L=0.18U W=10.66U
m64 N99 AGTPB VDD VDD P L=0.18U W=1.48U
m65 N99 AGTPB VSS VSS N L=0.18U W=0.94U
m66 AP45-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m67 AP45-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m68 N121 N83 VSS VSS N L=0.18U W=6.24U
m69 N120 N82 N121 VSS N L=0.18U W=6.24U
m7 N40 AI1_ VDD VDD P L=0.18U W=5.94U
m70 AP45-AIND0 AP45-AIN20 N120 VSS N L=0.18U W=6.24U
m71 AP45-AIND0 N83 VDD VDD P L=0.18U W=10.66U
m72 N119 N83 VSS VSS N L=0.18U W=6.24U
m73 AP45-AIND0 N82 VDD VDD P L=0.18U W=10.66U
m74 N118 N82 N119 VSS N L=0.18U W=6.24U
m75 AP45-AIND0 AP45-AIN20 VDD VDD P L=0.18U W=10.66U
m76 AP45-AIND0 AP45-AIN20 N118 VSS N L=0.18U W=6.24U
m77 AP45-APN1 YP1_1 VDD VDD P L=0.27U W=0.22U
m78 AP45-APN1 YP1_1 VSS VSS N L=0.54U W=0.22U
m79 YP1_1 AP45-APN1 VDD VDD P L=0.18U W=28.56U
m8 N40 AI1_ VSS VSS N L=0.18U W=2.87U
m80 YP1_1 AP45-APN1 VSS VSS N L=0.18U W=15.13U
m81 AP45-APN0 YP1_0 VDD VDD P L=0.27U W=0.22U
m82 AP45-APN0 YP1_0 VSS VSS N L=0.54U W=0.22U
m83 YP1_0 AP45-APN0 VDD VDD P L=0.18U W=28.56U
m84 YP1_0 AP45-APN0 VSS VSS N L=0.18U W=15.13U
m85 AP23-APN1 N130 AP23-AIND1 VSS N L=0.18U W=6.24U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD P L=0.18U W=10.66U
m87 N130 AGTPT VDD VDD P L=0.18U W=1.48U
m88 N130 AGTPT VSS VSS N L=0.18U W=0.94U
m89 AP23-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m9 N41 AI2_ VDD VDD P L=0.18U W=5.94U
m90 AP23-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m91 N124 AI1_ VDD VDD P L=0.18U W=5.94U
m92 N124 AI1_ VSS VSS N L=0.18U W=2.87U
m93 N125 AI2 VDD VDD P L=0.18U W=5.94U
m94 N125 AI2 VSS VSS N L=0.18U W=2.87U
m95 N159 N125 VSS VSS N L=0.18U W=6.24U
m96 N158 N124 N159 VSS N L=0.18U W=6.24U
m97 AP23-AIND1 AP23-AIN21 N158 VSS N L=0.18U W=6.24U
m98 AP23-AIND1 N125 VDD VDD P L=0.18U W=10.66U
m99 N157 N125 VSS VSS N L=0.18U W=6.24U
.ENDS RA1SHD4096X32HYP38
****
.SUBCKT RA1SHD4096X32HYP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32HYP38X: 192 flat devices **
XI0_0 A0 A1 A2 A0 A1 A2 AGTPB AGTPT VSS VSS VSS AY0 AY0_ BWEN OEI_ WEI YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32HYP38
.ENDS RA1SHD4096X32HYP38X
****
.SUBCKT RA1SHD4096X32HYP12R A0 ACONN0 AGTP AMX0 AY0 AY0_ BWEN CLK GSRCN GTPN
+  OEI_ RST WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32HYP12R: 50 flat devices **
d7 VSS A0 DN 0.3364P 2.32U
d8 VSS BWEN DN 0.3364P 2.32U
m1 N25 N28 VDD VDD P L=0.18U W=8.16U
m10 AP01-APN1 AGTP AP01-AIND1 VDD P L=0.18U W=10.66U
m11 N45 AGTP VDD VDD P L=0.18U W=1.48U
m12 N45 AGTP VSS VSS N L=0.18U W=0.94U
m13 AP01-AIN21 N25 VDD VDD P L=0.18U W=5.94U
m14 AP01-AIN21 N25 VSS VSS N L=0.18U W=2.87U
m15 N39 VSS VDD VDD P L=0.18U W=5.94U
m16 N39 VSS VSS VSS N L=0.18U W=2.87U
m17 N40 VSS VDD VDD P L=0.18U W=5.94U
m18 N40 VSS VSS VSS N L=0.18U W=2.87U
m19 N74 N40 VSS VSS N L=0.18U W=6.24U
m2 N25 N28 VSS VSS N L=0.18U W=4U
m20 N73 N39 N74 VSS N L=0.18U W=6.24U
m21 AP01-AIND1 AP01-AIN21 N73 VSS N L=0.18U W=6.24U
m22 AP01-AIND1 N40 VDD VDD P L=0.18U W=10.66U
m23 N72 N40 VSS VSS N L=0.18U W=6.24U
m24 AP01-AIND1 N39 VDD VDD P L=0.18U W=10.66U
m25 N71 N39 N72 VSS N L=0.18U W=6.24U
m26 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.18U W=10.66U
m27 AP01-AIND1 AP01-AIN21 N71 VSS N L=0.18U W=6.24U
m28 AP01-APN0 N56 AP01-AIND0 VSS N L=0.18U W=6.24U
m29 AP01-APN0 AGTP AP01-AIND0 VDD P L=0.18U W=10.66U
m3 N24 ACONN0 VDD VDD P L=0.18U W=8.16U
m30 N56 AGTP VDD VDD P L=0.18U W=1.48U
m31 N56 AGTP VSS VSS N L=0.18U W=0.94U
m32 AP01-AIN20 N24 VDD VDD P L=0.18U W=5.94U
m33 AP01-AIN20 N24 VSS VSS N L=0.18U W=2.87U
m34 N78 N40 VSS VSS N L=0.18U W=6.24U
m35 N77 N39 N78 VSS N L=0.18U W=6.24U
m36 AP01-AIND0 AP01-AIN20 N77 VSS N L=0.18U W=6.24U
m37 AP01-AIND0 N40 VDD VDD P L=0.18U W=10.66U
m38 N76 N40 VSS VSS N L=0.18U W=6.24U
m39 AP01-AIND0 N39 VDD VDD P L=0.18U W=10.66U
m4 N24 ACONN0 VSS VSS N L=0.18U W=4.02U
m40 N75 N39 N76 VSS N L=0.18U W=6.24U
m41 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.18U W=10.66U
m42 AP01-AIND0 AP01-AIN20 N75 VSS N L=0.18U W=6.24U
m43 AP01-APN1 AY0_ VDD VDD P L=0.27U W=0.22U
m44 AP01-APN1 AY0_ VSS VSS N L=0.54U W=0.22U
m45 AY0_ AP01-APN1 VDD VDD P L=0.18U W=28.56U
m46 AY0_ AP01-APN1 VSS VSS N L=0.18U W=15.13U
m47 AP01-APN0 AY0 VDD VDD P L=0.27U W=0.22U
m48 AP01-APN0 AY0 VSS VSS N L=0.54U W=0.22U
m49 AY0 AP01-APN0 VDD VDD P L=0.18U W=28.56U
m5 N28 ACONN0 VDD VDD P L=0.18U W=6.52U
m50 AY0 AP01-APN0 VSS VSS N L=0.18U W=15.13U
m6 N28 ACONN0 VSS VSS N L=0.18U W=3.2U
m9 AP01-APN1 N45 AP01-AIND1 VSS N L=0.18U W=6.24U
.ENDS RA1SHD4096X32HYP12R
****
.SUBCKT RA1SHD4096X32HYP12RX A0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32HYP12RX: 50 flat devices **
XI0_0 A0 A0 AGTP VSS AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32HYP12R
.ENDS RA1SHD4096X32HYP12RX
****
.SUBCKT RA1SHD4096X32Y_DECODE A0 A0_0 A1 A2 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN
+  OEI_ RST WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32Y_DECODE: 242 flat devices **
XI0_0 A0 A1 A2 AGTP AGTP AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32HYP38X
XI1_0 A0_0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32HYP12RX
.ENDS RA1SHD4096X32Y_DECODE
****
.SUBCKT RA1SHD4096X32HBF8 CEMX CEN CENI_ CEN_ CLK GSRCN GTP GTPN MBL OEI_ OEMX
+  OEN OENI_ OEN_ RST STOV STUBWE TMS WE WEI WEMX WEN WENI_ WEN_ VSS VDD
** RA1SHD4096X32HBF8: 91 flat devices **
d86 VSS WEN DN 0.3364P 2.32U
d87 VSS OEN DN 0.3364P 2.32U
d88 VSS CEN DN 0.3364P 2.32U
d89 VSS STOV DN 0.3364P 2.32U
d90 VSS CLK DN 0.3364P 2.32U
d91 VSS TMS DN 0.3364P 2.32U
m1 WE N44 VDD VDD P L=0.18U W=13.78U
m10 BF-CLKN CLK VSS VSS N L=0.36U W=1.44U
m11 N44 BF-TMS_ VDD VDD P L=0.18U W=6.12U
m12 N97 BF-TMS_ VSS VSS N L=0.18U W=4.59U
m13 N44 WENI_ VDD VDD P L=0.18U W=6.12U
m14 N44 WENI_ N97 VSS N L=0.18U W=4.59U
m15 BF-TMS_ TMS VDD VDD P L=0.18U W=2.95U
m16 BF-TMS_ TMS VSS VSS N L=0.18U W=1.52U
m17 OEI_ N57 VDD VDD P L=0.18U W=15.86U
m18 OEI_ N57 VSS VSS N L=0.18U W=8.16U
m19 N57 N60 VDD VDD P L=0.18U W=5.85U
m2 WE N44 VSS VSS N L=0.18U W=7.09U
m20 N57 N60 VSS VSS N L=0.18U W=3.01U
m21 N60 BF-TMS_ VDD VDD P L=0.18U W=2.27U
m22 N98 BF-TMS_ VSS VSS N L=0.18U W=2.22U
m23 N60 OENI_ VDD VDD P L=0.18U W=2.27U
m24 N60 OENI_ N98 VSS N L=0.18U W=2.22U
m25 N100 GTP VSS VSS N L=0.18U W=2.67U
m26 BF-RSRCN BF-CKSTOV N100 VSS N L=0.18U W=2.67U
m27 BF-RSRCN GTP VDD VDD P L=0.18U W=5.7U
m28 N99 GTP VSS VSS N L=0.18U W=2.67U
m29 BF-RSRCN BF-CKSTOV VDD VDD P L=0.18U W=5.7U
m3 BF-CENMML BF-CLKN N96 VDD P L=0.18U W=0.22U
m30 BF-RSRCN BF-CKSTOV N99 VSS N L=0.18U W=2.67U
m31 BF-RSTSRC BF-RSRCN VDD VDD P L=0.18U W=14.16U
m32 BF-RSTSRC BF-RSRCN VSS VSS N L=0.18U W=6.62U
m33 BF-CKSTOV STOV VDD VDD P L=0.18U W=2.68U
m34 N101 STOV VSS VSS N L=0.18U W=2.51U
m35 BF-CKSTOV CLK VDD VDD P L=0.18U W=2.68U
m36 BF-CKSTOV CLK N101 VSS N L=0.18U W=2.51U
m37 GTPN BF-GTPI N71 VSS N L=0.18U W=0.22U
m38 N37 N37 VDD VDD P L=0.18U W=0.22U
m39 GTPN BF-GTPI VDD VDD P L=0.18U W=0.22U
m4 N96 BF-CEL VDD VDD P L=0.18U W=0.22U
m40 N37 VDD VDD VDD P L=0.18U W=0.22U
m41 BF-GTPI GTPN VDD VDD P L=0.18U W=0.44U
m42 BF-GTPI GTPN VSS VSS N L=0.18U W=0.22U
m43 N71 N37 VSS VSS N L=0.18U W=0.22U
m44 N103 BF-CLKN VSS VSS N L=0.18U W=3.35U
m45 GSRCN BF-CEL N103 VSS N L=0.18U W=3.35U
m46 GSRCN BF-CLKN VDD VDD P L=0.18U W=5.72U
m47 N102 BF-CLKN VSS VSS N L=0.18U W=3.35U
m48 GSRCN BF-CEL VDD VDD P L=0.18U W=5.72U
m49 GSRCN BF-CEL N102 VSS N L=0.18U W=3.35U
m5 BF-CENMML CLK N95 VSS N L=0.18U W=0.22U
m50 N80 BF-CLKN VSS VSS N L=0.18U W=0.86U
m51 N82 CLK VDD VDD P L=0.18U W=2.17U
m52 BF-CENMML CENI_ N84 VDD P L=0.18U W=2.17U
m53 BF-CENMML CENI_ N80 VSS N L=0.18U W=0.85U
m54 N84 TMS N82 VDD P L=0.18U W=2.17U
m55 BF-CENMML TMS N80 VSS N L=0.18U W=0.85U
m56 RST BF-MBLN VDD VDD P L=0.18U W=3.3U
m57 RST BF-RSTSRC VDD VDD P L=0.18U W=22.49U
m58 BF-MBLN MBL VDD VDD P L=0.18U W=9.16U
m59 BF-MBLN MBL VSS VSS N L=0.18U W=3.06U
m6 N95 BF-CEL VSS VSS N L=0.18U W=0.22U
m60 WEN_ WEN VDD VDD P L=0.18U W=3.12U
m61 WEN_ WEN VSS VSS N L=0.18U W=1.53U
m62 OEN_ OEN VDD VDD P L=0.18U W=1.21U
m63 OEN_ OEN VSS VSS N L=0.18U W=0.59U
m64 CEN_ CEN VDD VDD P L=0.18U W=2.6U
m65 CEN_ CEN VSS VSS N L=0.18U W=1.28U
m66 RST BF-MBLN N113 VSS N L=0.18U W=2.74U
m67 N113 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m68 RST BF-MBLN N112 VSS N L=0.18U W=2.74U
m69 N112 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m7 BF-CEL BF-CENMML VDD VDD P L=0.18U W=2.63U
m70 RST BF-MBLN N111 VSS N L=0.18U W=2.74U
m71 N111 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m72 RST BF-MBLN N110 VSS N L=0.18U W=2.74U
m73 N110 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m74 RST BF-MBLN N109 VSS N L=0.18U W=2.74U
m75 N109 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m76 RST BF-MBLN N108 VSS N L=0.18U W=2.74U
m77 N108 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m78 RST BF-MBLN N107 VSS N L=0.18U W=2.74U
m79 N107 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m8 BF-CEL BF-CENMML VSS VSS N L=0.18U W=1.37U
m80 RST BF-MBLN N106 VSS N L=0.18U W=2.74U
m81 N106 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m82 RST BF-MBLN N105 VSS N L=0.18U W=2.74U
m83 N105 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m84 RST BF-MBLN N104 VSS N L=0.18U W=2.74U
m85 N104 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m9 BF-CLKN CLK VDD VDD P L=0.18U W=3.07U
.ENDS RA1SHD4096X32HBF8
****
.SUBCKT RA1SHD4096X32HBFX CEN CEN_ CLK GSRCN GTP GTPN MBL OEI_ OEN OEN_ RST
+  STUBWE WE WEI WEN_ VSS VDD
** RA1SHD4096X32HBFX: 91 flat devices **
XI0_0 VSS CEN CEN_ CEN_ CLK GSRCN GTP GTPN MBL OEI_ VSS OEN OEN_ OEN_ RST VSS
+  STUBWE VSS WE WEI VSS VSS WEN_ WEN_ VSS VDD RA1SHD4096X32HBF8
.ENDS RA1SHD4096X32HBFX
****
.SUBCKT RA1SHD4096X32CCMWG BL BL_ MWLB MWLT MWPB MWPT VSS VDD
** RA1SHD4096X32CCMWG: 12 flat devices **
m1 BL MWPT COREDT VSS N L=0.29U W=0.22U
m10 N18 VSS VDD VDD P L=0.19U W=0.22U
m11 COREDB VSS VSS VSS N L=0.18U W=0.25U
m12 COREDB_ VSS VSS VSS N L=0.18U W=0.25U
m2 BL_ MWPT COREDT_ VSS N L=0.29U W=0.22U
m3 BL MWPB COREDB VSS N L=0.29U W=0.22U
m4 BL_ MWPB COREDB_ VSS N L=0.29U W=0.22U
m5 COREDT VSS VSS VSS N L=0.18U W=0.25U
m6 COREDT_ VSS VSS VSS N L=0.18U W=0.25U
m7 N12 VSS VDD VDD P L=0.19U W=0.22U
m8 N14 VSS VDD VDD P L=0.19U W=0.22U
m9 N16 VSS VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD4096X32CCMWG
****
.SUBCKT RA1SHD4096X32CCMWP BL BL_ MWLB MWLT MWPB MWPT VSS VDD
** RA1SHD4096X32CCMWP: 12 flat devices **
m1 BL MWPT COREDT VSS N L=0.29U W=0.22U
m10 N18 VSS VDD VDD P L=0.19U W=0.22U
m11 COREDB VSS VSS VSS N L=0.18U W=0.25U
m12 COREDB_ VSS VSS VSS N L=0.18U W=0.25U
m2 BL_ MWPT COREDT_ VSS N L=0.29U W=0.22U
m3 BL MWPB COREDB VSS N L=0.29U W=0.22U
m4 BL_ MWPB COREDB_ VSS N L=0.29U W=0.22U
m5 COREDT VSS VSS VSS N L=0.18U W=0.25U
m6 COREDT_ VSS VSS VSS N L=0.18U W=0.25U
m7 N12 VSS VDD VDD P L=0.19U W=0.22U
m8 N14 VSS VDD VDD P L=0.19U W=0.22U
m9 N16 VSS VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD4096X32CCMWP
****
.SUBCKT RA1SHD4096X32FLMWG BL0 BL0_ BL1 BL1_ MWL WP0 WP1 WP2 WP3 VSS VDD
** RA1SHD4096X32FLMWG: 24 flat devices **
m1 BL0 WP1 N12 VSS N L=0.29U W=0.22U
m10 N22 VSS VDD VDD P L=0.19U W=0.22U
m11 N14 VSS VSS VSS N L=0.18U W=0.25U
m12 N15 VSS VSS VSS N L=0.18U W=0.25U
m13 BL1 WP3 N24 VSS N L=0.29U W=0.22U
m14 BL1_ WP3 N25 VSS N L=0.29U W=0.22U
m15 BL1 WP2 N26 VSS N L=0.29U W=0.22U
m16 BL1_ WP2 N27 VSS N L=0.29U W=0.22U
m17 N24 VSS VSS VSS N L=0.18U W=0.25U
m18 N25 VSS VSS VSS N L=0.18U W=0.25U
m19 N28 VSS VDD VDD P L=0.19U W=0.22U
m2 BL0_ WP3 N13 VSS N L=0.29U W=0.22U
m20 N30 VSS VDD VDD P L=0.19U W=0.22U
m21 N32 VSS VDD VDD P L=0.19U W=0.22U
m22 N34 VSS VDD VDD P L=0.19U W=0.22U
m23 N26 VSS VSS VSS N L=0.18U W=0.25U
m24 N27 VSS VSS VSS N L=0.18U W=0.25U
m3 BL0 WP0 N14 VSS N L=0.29U W=0.22U
m4 BL0_ WP2 N15 VSS N L=0.29U W=0.22U
m5 N12 VSS VSS VSS N L=0.18U W=0.25U
m6 N13 VSS VSS VSS N L=0.18U W=0.25U
m7 N16 VSS VDD VDD P L=0.19U W=0.22U
m8 N18 VSS VDD VDD P L=0.19U W=0.22U
m9 N20 VSS VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD4096X32FLMWG
****
.SUBCKT RA1SHD4096X32MODEL_ROW_16 BL BL0 BL0_ BL1 BL1_ BL_ BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16
+  BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28
+  BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40
+  BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52
+  BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64
+  BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76
+  BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88
+  BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100
+  BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110
+  BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120
+  BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127 BL_128 BL_129 BL_130
+  BL_131 BL_132 BL_133 BL_134 BL_135 BL_136 BL_137 BL_138 BL_139 BL_140
+  BL_141 BL_142 BL_143 BL_144 BL_145 BL_146 BL_147 BL_148 BL_149 BL_150
+  BL_151 BL_152 BL_153 BL_154 BL_155 BL_156 BL_157 BL_158 BL_159 BL_160
+  BL_161 BL_162 BL_163 BL_164 BL_165 BL_166 BL_167 BL_168 BL_169 BL_170
+  BL_171 BL_172 BL_173 BL_174 BL_175 BL_176 BL_177 BL_178 BL_179 BL_180
+  BL_181 BL_182 BL_183 BL_184 BL_185 BL_186 BL_187 BL_188 BL_189 BL_190
+  BL_191 BL_192 BL_193 BL_194 BL_195 BL_196 BL_197 BL_198 BL_199 BL_200
+  BL_201 BL_202 BL_203 BL_204 BL_205 BL_206 BL_207 BL_208 BL_209 BL_210
+  BL_211 BL_212 BL_213 BL_214 BL_215 BL_216 BL_217 BL_218 BL_219 BL_220
+  BL_221 BL_222 BL_223 BL_224 BL_225 BL_226 BL_227 BL_228 BL_229 BL_230
+  BL_231 BL_232 BL_233 BL_234 BL_235 BL_236 BL_237 BL_238 BL_239 BL_240
+  BL_241 BL_242 BL_243 BL_244 BL_245 BL_246 BL_247 BL_248 BL_249 BL_250
+  BL_251 BL_252 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39
+  BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49
+  BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59
+  BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69
+  BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79
+  BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89
+  BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99
+  BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108
+  BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117
+  BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126
+  BL__127 BL__128 BL__129 BL__130 BL__131 BL__132 BL__133 BL__134 BL__135
+  BL__136 BL__137 BL__138 BL__139 BL__140 BL__141 BL__142 BL__143 BL__144
+  BL__145 BL__146 BL__147 BL__148 BL__149 BL__150 BL__151 BL__152 BL__153
+  BL__154 BL__155 BL__156 BL__157 BL__158 BL__159 BL__160 BL__161 BL__162
+  BL__163 BL__164 BL__165 BL__166 BL__167 BL__168 BL__169 BL__170 BL__171
+  BL__172 BL__173 BL__174 BL__175 BL__176 BL__177 BL__178 BL__179 BL__180
+  BL__181 BL__182 BL__183 BL__184 BL__185 BL__186 BL__187 BL__188 BL__189
+  BL__190 BL__191 BL__192 BL__193 BL__194 BL__195 BL__196 BL__197 BL__198
+  BL__199 BL__200 BL__201 BL__202 BL__203 BL__204 BL__205 BL__206 BL__207
+  BL__208 BL__209 BL__210 BL__211 BL__212 BL__213 BL__214 BL__215 BL__216
+  BL__217 BL__218 BL__219 BL__220 BL__221 BL__222 BL__223 BL__224 BL__225
+  BL__226 BL__227 BL__228 BL__229 BL__230 BL__231 BL__232 BL__233 BL__234
+  BL__235 BL__236 BL__237 BL__238 BL__239 BL__240 BL__241 BL__242 BL__243
+  BL__244 BL__245 BL__246 BL__247 BL__248 BL__249 BL__250 BL__251 BL__252
+  MWLB WL VSS VDD
** RA1SHD4096X32MODEL_ROW_16: 4608 flat devices **
XI0_0 BL BL_ MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI0_2 BL BL_ WL WL VSS VDD RA1SHD4096X32CCG
XI100_0 BL_96 BL__96 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI100_2 BL_96 BL__96 WL WL VSS VDD RA1SHD4096X32CCP
XI101_0 BL_97 BL__97 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI101_2 BL_97 BL__97 WL WL VSS VDD RA1SHD4096X32CCP
XI102_0 BL_98 BL__98 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI102_2 BL_98 BL__98 WL WL VSS VDD RA1SHD4096X32CCG
XI103_0 BL_99 BL__99 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI103_2 BL_99 BL__99 WL WL VSS VDD RA1SHD4096X32CCG
XI104_0 BL_100 BL__100 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI104_2 BL_100 BL__100 WL WL VSS VDD RA1SHD4096X32CCP
XI105_0 BL_101 BL__101 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI105_2 BL_101 BL__101 WL WL VSS VDD RA1SHD4096X32CCP
XI106_0 BL_102 BL__102 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI106_2 BL_102 BL__102 WL WL VSS VDD RA1SHD4096X32CCG
XI107_0 BL_103 BL__103 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI107_2 BL_103 BL__103 WL WL VSS VDD RA1SHD4096X32CCG
XI108_0 BL_104 BL__104 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI108_2 BL_104 BL__104 WL WL VSS VDD RA1SHD4096X32CCP
XI109_0 BL_105 BL__105 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI109_2 BL_105 BL__105 WL WL VSS VDD RA1SHD4096X32CCP
XI10_0 BL_9 BL__9 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI10_2 BL_9 BL__9 WL WL VSS VDD RA1SHD4096X32CCP
XI110_0 BL_106 BL__106 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI110_2 BL_106 BL__106 WL WL VSS VDD RA1SHD4096X32CCG
XI111_0 BL_107 BL__107 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI111_2 BL_107 BL__107 WL WL VSS VDD RA1SHD4096X32CCG
XI112_0 BL_108 BL__108 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI112_2 BL_108 BL__108 WL WL VSS VDD RA1SHD4096X32CCP
XI113_0 BL_109 BL__109 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI113_2 BL_109 BL__109 WL WL VSS VDD RA1SHD4096X32CCP
XI114_0 BL_110 BL__110 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI114_2 BL_110 BL__110 WL WL VSS VDD RA1SHD4096X32CCG
XI115_0 BL_111 BL__111 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI115_2 BL_111 BL__111 WL WL VSS VDD RA1SHD4096X32CCG
XI116_0 BL_112 BL__112 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI116_2 BL_112 BL__112 WL WL VSS VDD RA1SHD4096X32CCP
XI117_0 BL_113 BL__113 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI117_2 BL_113 BL__113 WL WL VSS VDD RA1SHD4096X32CCP
XI118_0 BL_114 BL__114 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI118_2 BL_114 BL__114 WL WL VSS VDD RA1SHD4096X32CCG
XI119_0 BL_115 BL__115 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI119_2 BL_115 BL__115 WL WL VSS VDD RA1SHD4096X32CCG
XI11_0 BL_10 BL__10 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI11_2 BL_10 BL__10 WL WL VSS VDD RA1SHD4096X32CCG
XI120_0 BL_116 BL__116 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI120_2 BL_116 BL__116 WL WL VSS VDD RA1SHD4096X32CCP
XI121_0 BL_117 BL__117 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI121_2 BL_117 BL__117 WL WL VSS VDD RA1SHD4096X32CCP
XI122_0 BL_118 BL__118 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI122_2 BL_118 BL__118 WL WL VSS VDD RA1SHD4096X32CCG
XI123_0 BL_119 BL__119 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI123_2 BL_119 BL__119 WL WL VSS VDD RA1SHD4096X32CCG
XI124_0 BL_120 BL__120 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI124_2 BL_120 BL__120 WL WL VSS VDD RA1SHD4096X32CCP
XI125_0 BL_121 BL__121 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI125_2 BL_121 BL__121 WL WL VSS VDD RA1SHD4096X32CCP
XI126_0 BL_122 BL__122 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI126_2 BL_122 BL__122 WL WL VSS VDD RA1SHD4096X32CCG
XI127_0 BL_123 BL__123 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI127_2 BL_123 BL__123 WL WL VSS VDD RA1SHD4096X32CCG
XI128_0 BL_124 BL__124 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI128_2 BL_124 BL__124 WL WL VSS VDD RA1SHD4096X32CCP
XI129_0 BL_125 BL__125 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI129_2 BL_125 BL__125 WL WL VSS VDD RA1SHD4096X32CCP
XI12_0 BL_11 BL__11 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI12_2 BL_11 BL__11 WL WL VSS VDD RA1SHD4096X32CCG
XI130_0 BL_126 BL__126 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI130_2 BL_126 BL__126 WL WL VSS VDD RA1SHD4096X32CCG
XI132_0 BL0 BL0_ BL1 BL1_ MWLB MWLB MWLB VSS VSS VSS VDD RA1SHD4096X32FLMWG
XI132_2 BL0 BL0_ WL WL VSS VDD RA1SHD4096X32CCG
XI133_2 BL1 BL1_ WL WL VSS VDD RA1SHD4096X32CCP
XI134_0 BL_127 BL__127 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI134_2 BL_127 BL__127 WL WL VSS VDD RA1SHD4096X32CCP
XI135_0 BL_128 BL__128 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI135_2 BL_128 BL__128 WL WL VSS VDD RA1SHD4096X32CCG
XI136_0 BL_129 BL__129 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI136_2 BL_129 BL__129 WL WL VSS VDD RA1SHD4096X32CCG
XI137_0 BL_130 BL__130 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI137_2 BL_130 BL__130 WL WL VSS VDD RA1SHD4096X32CCP
XI138_0 BL_131 BL__131 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI138_2 BL_131 BL__131 WL WL VSS VDD RA1SHD4096X32CCP
XI139_0 BL_132 BL__132 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI139_2 BL_132 BL__132 WL WL VSS VDD RA1SHD4096X32CCG
XI13_0 BL_12 BL__12 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI13_2 BL_12 BL__12 WL WL VSS VDD RA1SHD4096X32CCP
XI140_0 BL_133 BL__133 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI140_2 BL_133 BL__133 WL WL VSS VDD RA1SHD4096X32CCG
XI141_0 BL_134 BL__134 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI141_2 BL_134 BL__134 WL WL VSS VDD RA1SHD4096X32CCP
XI142_0 BL_135 BL__135 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI142_2 BL_135 BL__135 WL WL VSS VDD RA1SHD4096X32CCP
XI143_0 BL_136 BL__136 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI143_2 BL_136 BL__136 WL WL VSS VDD RA1SHD4096X32CCG
XI144_0 BL_137 BL__137 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI144_2 BL_137 BL__137 WL WL VSS VDD RA1SHD4096X32CCG
XI145_0 BL_138 BL__138 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI145_2 BL_138 BL__138 WL WL VSS VDD RA1SHD4096X32CCP
XI146_0 BL_139 BL__139 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI146_2 BL_139 BL__139 WL WL VSS VDD RA1SHD4096X32CCP
XI147_0 BL_140 BL__140 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI147_2 BL_140 BL__140 WL WL VSS VDD RA1SHD4096X32CCG
XI148_0 BL_141 BL__141 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI148_2 BL_141 BL__141 WL WL VSS VDD RA1SHD4096X32CCG
XI149_0 BL_142 BL__142 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI149_2 BL_142 BL__142 WL WL VSS VDD RA1SHD4096X32CCP
XI14_0 BL_13 BL__13 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI14_2 BL_13 BL__13 WL WL VSS VDD RA1SHD4096X32CCP
XI150_0 BL_143 BL__143 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI150_2 BL_143 BL__143 WL WL VSS VDD RA1SHD4096X32CCP
XI151_0 BL_144 BL__144 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI151_2 BL_144 BL__144 WL WL VSS VDD RA1SHD4096X32CCG
XI152_0 BL_145 BL__145 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI152_2 BL_145 BL__145 WL WL VSS VDD RA1SHD4096X32CCG
XI153_0 BL_146 BL__146 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI153_2 BL_146 BL__146 WL WL VSS VDD RA1SHD4096X32CCP
XI154_0 BL_147 BL__147 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI154_2 BL_147 BL__147 WL WL VSS VDD RA1SHD4096X32CCP
XI155_0 BL_148 BL__148 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI155_2 BL_148 BL__148 WL WL VSS VDD RA1SHD4096X32CCG
XI156_0 BL_149 BL__149 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI156_2 BL_149 BL__149 WL WL VSS VDD RA1SHD4096X32CCG
XI157_0 BL_150 BL__150 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI157_2 BL_150 BL__150 WL WL VSS VDD RA1SHD4096X32CCP
XI158_0 BL_151 BL__151 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI158_2 BL_151 BL__151 WL WL VSS VDD RA1SHD4096X32CCP
XI159_0 BL_152 BL__152 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI159_2 BL_152 BL__152 WL WL VSS VDD RA1SHD4096X32CCG
XI15_0 BL_14 BL__14 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI15_2 BL_14 BL__14 WL WL VSS VDD RA1SHD4096X32CCG
XI160_0 BL_153 BL__153 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI160_2 BL_153 BL__153 WL WL VSS VDD RA1SHD4096X32CCG
XI161_0 BL_154 BL__154 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI161_2 BL_154 BL__154 WL WL VSS VDD RA1SHD4096X32CCP
XI162_0 BL_155 BL__155 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI162_2 BL_155 BL__155 WL WL VSS VDD RA1SHD4096X32CCP
XI163_0 BL_156 BL__156 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI163_2 BL_156 BL__156 WL WL VSS VDD RA1SHD4096X32CCG
XI165_0 BL_157 BL__157 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI165_2 BL_157 BL__157 WL WL VSS VDD RA1SHD4096X32CCG
XI166_0 BL_158 BL__158 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI166_2 BL_158 BL__158 WL WL VSS VDD RA1SHD4096X32CCP
XI167_0 BL_159 BL__159 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI167_2 BL_159 BL__159 WL WL VSS VDD RA1SHD4096X32CCP
XI168_0 BL_160 BL__160 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI168_2 BL_160 BL__160 WL WL VSS VDD RA1SHD4096X32CCG
XI169_0 BL_161 BL__161 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI169_2 BL_161 BL__161 WL WL VSS VDD RA1SHD4096X32CCG
XI16_0 BL_15 BL__15 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI16_2 BL_15 BL__15 WL WL VSS VDD RA1SHD4096X32CCG
XI170_0 BL_162 BL__162 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI170_2 BL_162 BL__162 WL WL VSS VDD RA1SHD4096X32CCP
XI171_0 BL_163 BL__163 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI171_2 BL_163 BL__163 WL WL VSS VDD RA1SHD4096X32CCP
XI172_0 BL_164 BL__164 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI172_2 BL_164 BL__164 WL WL VSS VDD RA1SHD4096X32CCG
XI173_0 BL_165 BL__165 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI173_2 BL_165 BL__165 WL WL VSS VDD RA1SHD4096X32CCG
XI174_0 BL_166 BL__166 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI174_2 BL_166 BL__166 WL WL VSS VDD RA1SHD4096X32CCP
XI175_0 BL_167 BL__167 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI175_2 BL_167 BL__167 WL WL VSS VDD RA1SHD4096X32CCP
XI176_0 BL_168 BL__168 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI176_2 BL_168 BL__168 WL WL VSS VDD RA1SHD4096X32CCG
XI177_0 BL_169 BL__169 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI177_2 BL_169 BL__169 WL WL VSS VDD RA1SHD4096X32CCG
XI178_0 BL_170 BL__170 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI178_2 BL_170 BL__170 WL WL VSS VDD RA1SHD4096X32CCP
XI179_0 BL_171 BL__171 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI179_2 BL_171 BL__171 WL WL VSS VDD RA1SHD4096X32CCP
XI17_0 BL_16 BL__16 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI17_2 BL_16 BL__16 WL WL VSS VDD RA1SHD4096X32CCP
XI180_0 BL_172 BL__172 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI180_2 BL_172 BL__172 WL WL VSS VDD RA1SHD4096X32CCG
XI181_0 BL_173 BL__173 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI181_2 BL_173 BL__173 WL WL VSS VDD RA1SHD4096X32CCG
XI182_0 BL_174 BL__174 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI182_2 BL_174 BL__174 WL WL VSS VDD RA1SHD4096X32CCP
XI183_0 BL_175 BL__175 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI183_2 BL_175 BL__175 WL WL VSS VDD RA1SHD4096X32CCP
XI184_0 BL_176 BL__176 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI184_2 BL_176 BL__176 WL WL VSS VDD RA1SHD4096X32CCG
XI185_0 BL_177 BL__177 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI185_2 BL_177 BL__177 WL WL VSS VDD RA1SHD4096X32CCG
XI186_0 BL_178 BL__178 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI186_2 BL_178 BL__178 WL WL VSS VDD RA1SHD4096X32CCP
XI187_0 BL_179 BL__179 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI187_2 BL_179 BL__179 WL WL VSS VDD RA1SHD4096X32CCP
XI188_0 BL_180 BL__180 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI188_2 BL_180 BL__180 WL WL VSS VDD RA1SHD4096X32CCG
XI189_0 BL_181 BL__181 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI189_2 BL_181 BL__181 WL WL VSS VDD RA1SHD4096X32CCG
XI18_0 BL_17 BL__17 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI18_2 BL_17 BL__17 WL WL VSS VDD RA1SHD4096X32CCP
XI190_0 BL_182 BL__182 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI190_2 BL_182 BL__182 WL WL VSS VDD RA1SHD4096X32CCP
XI191_0 BL_183 BL__183 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI191_2 BL_183 BL__183 WL WL VSS VDD RA1SHD4096X32CCP
XI192_0 BL_184 BL__184 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI192_2 BL_184 BL__184 WL WL VSS VDD RA1SHD4096X32CCG
XI193_0 BL_185 BL__185 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI193_2 BL_185 BL__185 WL WL VSS VDD RA1SHD4096X32CCG
XI194_0 BL_186 BL__186 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI194_2 BL_186 BL__186 WL WL VSS VDD RA1SHD4096X32CCP
XI195_0 BL_187 BL__187 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI195_2 BL_187 BL__187 WL WL VSS VDD RA1SHD4096X32CCP
XI196_0 BL_188 BL__188 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI196_2 BL_188 BL__188 WL WL VSS VDD RA1SHD4096X32CCG
XI198_0 BL_189 BL__189 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI198_2 BL_189 BL__189 WL WL VSS VDD RA1SHD4096X32CCG
XI199_0 BL_190 BL__190 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI199_2 BL_190 BL__190 WL WL VSS VDD RA1SHD4096X32CCP
XI19_0 BL_18 BL__18 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI19_2 BL_18 BL__18 WL WL VSS VDD RA1SHD4096X32CCG
XI1_0 BL_0 BL__0 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI1_2 BL_0 BL__0 WL WL VSS VDD RA1SHD4096X32CCP
XI200_0 BL_191 BL__191 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI200_2 BL_191 BL__191 WL WL VSS VDD RA1SHD4096X32CCP
XI201_0 BL_192 BL__192 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI201_2 BL_192 BL__192 WL WL VSS VDD RA1SHD4096X32CCG
XI202_0 BL_193 BL__193 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI202_2 BL_193 BL__193 WL WL VSS VDD RA1SHD4096X32CCG
XI203_0 BL_194 BL__194 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI203_2 BL_194 BL__194 WL WL VSS VDD RA1SHD4096X32CCP
XI204_0 BL_195 BL__195 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI204_2 BL_195 BL__195 WL WL VSS VDD RA1SHD4096X32CCP
XI205_0 BL_196 BL__196 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI205_2 BL_196 BL__196 WL WL VSS VDD RA1SHD4096X32CCG
XI206_0 BL_197 BL__197 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI206_2 BL_197 BL__197 WL WL VSS VDD RA1SHD4096X32CCG
XI207_0 BL_198 BL__198 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI207_2 BL_198 BL__198 WL WL VSS VDD RA1SHD4096X32CCP
XI208_0 BL_199 BL__199 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI208_2 BL_199 BL__199 WL WL VSS VDD RA1SHD4096X32CCP
XI209_0 BL_200 BL__200 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI209_2 BL_200 BL__200 WL WL VSS VDD RA1SHD4096X32CCG
XI20_0 BL_19 BL__19 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI20_2 BL_19 BL__19 WL WL VSS VDD RA1SHD4096X32CCG
XI210_0 BL_201 BL__201 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI210_2 BL_201 BL__201 WL WL VSS VDD RA1SHD4096X32CCG
XI211_0 BL_202 BL__202 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI211_2 BL_202 BL__202 WL WL VSS VDD RA1SHD4096X32CCP
XI212_0 BL_203 BL__203 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI212_2 BL_203 BL__203 WL WL VSS VDD RA1SHD4096X32CCP
XI213_0 BL_204 BL__204 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI213_2 BL_204 BL__204 WL WL VSS VDD RA1SHD4096X32CCG
XI214_0 BL_205 BL__205 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI214_2 BL_205 BL__205 WL WL VSS VDD RA1SHD4096X32CCG
XI215_0 BL_206 BL__206 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI215_2 BL_206 BL__206 WL WL VSS VDD RA1SHD4096X32CCP
XI216_0 BL_207 BL__207 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI216_2 BL_207 BL__207 WL WL VSS VDD RA1SHD4096X32CCP
XI217_0 BL_208 BL__208 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI217_2 BL_208 BL__208 WL WL VSS VDD RA1SHD4096X32CCG
XI218_0 BL_209 BL__209 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI218_2 BL_209 BL__209 WL WL VSS VDD RA1SHD4096X32CCG
XI219_0 BL_210 BL__210 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI219_2 BL_210 BL__210 WL WL VSS VDD RA1SHD4096X32CCP
XI21_0 BL_20 BL__20 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI21_2 BL_20 BL__20 WL WL VSS VDD RA1SHD4096X32CCP
XI220_0 BL_211 BL__211 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI220_2 BL_211 BL__211 WL WL VSS VDD RA1SHD4096X32CCP
XI221_0 BL_212 BL__212 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI221_2 BL_212 BL__212 WL WL VSS VDD RA1SHD4096X32CCG
XI222_0 BL_213 BL__213 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI222_2 BL_213 BL__213 WL WL VSS VDD RA1SHD4096X32CCG
XI223_0 BL_214 BL__214 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI223_2 BL_214 BL__214 WL WL VSS VDD RA1SHD4096X32CCP
XI224_0 BL_215 BL__215 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI224_2 BL_215 BL__215 WL WL VSS VDD RA1SHD4096X32CCP
XI225_0 BL_216 BL__216 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI225_2 BL_216 BL__216 WL WL VSS VDD RA1SHD4096X32CCG
XI226_0 BL_217 BL__217 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI226_2 BL_217 BL__217 WL WL VSS VDD RA1SHD4096X32CCG
XI227_0 BL_218 BL__218 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI227_2 BL_218 BL__218 WL WL VSS VDD RA1SHD4096X32CCP
XI228_0 BL_219 BL__219 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI228_2 BL_219 BL__219 WL WL VSS VDD RA1SHD4096X32CCP
XI229_0 BL_220 BL__220 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI229_2 BL_220 BL__220 WL WL VSS VDD RA1SHD4096X32CCG
XI22_0 BL_21 BL__21 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI22_2 BL_21 BL__21 WL WL VSS VDD RA1SHD4096X32CCP
XI231_0 BL_221 BL__221 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI231_2 BL_221 BL__221 WL WL VSS VDD RA1SHD4096X32CCG
XI232_0 BL_222 BL__222 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI232_2 BL_222 BL__222 WL WL VSS VDD RA1SHD4096X32CCP
XI233_0 BL_223 BL__223 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI233_2 BL_223 BL__223 WL WL VSS VDD RA1SHD4096X32CCP
XI234_0 BL_224 BL__224 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI234_2 BL_224 BL__224 WL WL VSS VDD RA1SHD4096X32CCG
XI235_0 BL_225 BL__225 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI235_2 BL_225 BL__225 WL WL VSS VDD RA1SHD4096X32CCG
XI236_0 BL_226 BL__226 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI236_2 BL_226 BL__226 WL WL VSS VDD RA1SHD4096X32CCP
XI237_0 BL_227 BL__227 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI237_2 BL_227 BL__227 WL WL VSS VDD RA1SHD4096X32CCP
XI238_0 BL_228 BL__228 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI238_2 BL_228 BL__228 WL WL VSS VDD RA1SHD4096X32CCG
XI239_0 BL_229 BL__229 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI239_2 BL_229 BL__229 WL WL VSS VDD RA1SHD4096X32CCG
XI23_0 BL_22 BL__22 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI23_2 BL_22 BL__22 WL WL VSS VDD RA1SHD4096X32CCG
XI240_0 BL_230 BL__230 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI240_2 BL_230 BL__230 WL WL VSS VDD RA1SHD4096X32CCP
XI241_0 BL_231 BL__231 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI241_2 BL_231 BL__231 WL WL VSS VDD RA1SHD4096X32CCP
XI242_0 BL_232 BL__232 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI242_2 BL_232 BL__232 WL WL VSS VDD RA1SHD4096X32CCG
XI243_0 BL_233 BL__233 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI243_2 BL_233 BL__233 WL WL VSS VDD RA1SHD4096X32CCG
XI244_0 BL_234 BL__234 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI244_2 BL_234 BL__234 WL WL VSS VDD RA1SHD4096X32CCP
XI245_0 BL_235 BL__235 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI245_2 BL_235 BL__235 WL WL VSS VDD RA1SHD4096X32CCP
XI246_0 BL_236 BL__236 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI246_2 BL_236 BL__236 WL WL VSS VDD RA1SHD4096X32CCG
XI247_0 BL_237 BL__237 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI247_2 BL_237 BL__237 WL WL VSS VDD RA1SHD4096X32CCG
XI248_0 BL_238 BL__238 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI248_2 BL_238 BL__238 WL WL VSS VDD RA1SHD4096X32CCP
XI249_0 BL_239 BL__239 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI249_2 BL_239 BL__239 WL WL VSS VDD RA1SHD4096X32CCP
XI24_0 BL_23 BL__23 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI24_2 BL_23 BL__23 WL WL VSS VDD RA1SHD4096X32CCG
XI250_0 BL_240 BL__240 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI250_2 BL_240 BL__240 WL WL VSS VDD RA1SHD4096X32CCG
XI251_0 BL_241 BL__241 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI251_2 BL_241 BL__241 WL WL VSS VDD RA1SHD4096X32CCG
XI252_0 BL_242 BL__242 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI252_2 BL_242 BL__242 WL WL VSS VDD RA1SHD4096X32CCP
XI253_0 BL_243 BL__243 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI253_2 BL_243 BL__243 WL WL VSS VDD RA1SHD4096X32CCP
XI254_0 BL_244 BL__244 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI254_2 BL_244 BL__244 WL WL VSS VDD RA1SHD4096X32CCG
XI255_0 BL_245 BL__245 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI255_2 BL_245 BL__245 WL WL VSS VDD RA1SHD4096X32CCG
XI256_0 BL_246 BL__246 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI256_2 BL_246 BL__246 WL WL VSS VDD RA1SHD4096X32CCP
XI257_0 BL_247 BL__247 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI257_2 BL_247 BL__247 WL WL VSS VDD RA1SHD4096X32CCP
XI258_0 BL_248 BL__248 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI258_2 BL_248 BL__248 WL WL VSS VDD RA1SHD4096X32CCG
XI259_0 BL_249 BL__249 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI259_2 BL_249 BL__249 WL WL VSS VDD RA1SHD4096X32CCG
XI25_0 BL_24 BL__24 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI25_2 BL_24 BL__24 WL WL VSS VDD RA1SHD4096X32CCP
XI260_0 BL_250 BL__250 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI260_2 BL_250 BL__250 WL WL VSS VDD RA1SHD4096X32CCP
XI261_0 BL_251 BL__251 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWP
XI261_2 BL_251 BL__251 WL WL VSS VDD RA1SHD4096X32CCP
XI262_0 BL_252 BL__252 VSS VSS VSS VSS VSS VDD RA1SHD4096X32CCMWG
XI262_2 BL_252 BL__252 WL WL VSS VDD RA1SHD4096X32CCG
XI26_0 BL_25 BL__25 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI26_2 BL_25 BL__25 WL WL VSS VDD RA1SHD4096X32CCP
XI27_0 BL_26 BL__26 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI27_2 BL_26 BL__26 WL WL VSS VDD RA1SHD4096X32CCG
XI28_0 BL_27 BL__27 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI28_2 BL_27 BL__27 WL WL VSS VDD RA1SHD4096X32CCG
XI29_0 BL_28 BL__28 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI29_2 BL_28 BL__28 WL WL VSS VDD RA1SHD4096X32CCP
XI2_0 BL_1 BL__1 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI2_2 BL_1 BL__1 WL WL VSS VDD RA1SHD4096X32CCP
XI30_0 BL_29 BL__29 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI30_2 BL_29 BL__29 WL WL VSS VDD RA1SHD4096X32CCP
XI31_0 BL_30 BL__30 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI31_2 BL_30 BL__30 WL WL VSS VDD RA1SHD4096X32CCG
XI33_0 BL_31 BL__31 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI33_2 BL_31 BL__31 WL WL VSS VDD RA1SHD4096X32CCG
XI34_0 BL_32 BL__32 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI34_2 BL_32 BL__32 WL WL VSS VDD RA1SHD4096X32CCP
XI35_0 BL_33 BL__33 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI35_2 BL_33 BL__33 WL WL VSS VDD RA1SHD4096X32CCP
XI36_0 BL_34 BL__34 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI36_2 BL_34 BL__34 WL WL VSS VDD RA1SHD4096X32CCG
XI37_0 BL_35 BL__35 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI37_2 BL_35 BL__35 WL WL VSS VDD RA1SHD4096X32CCG
XI38_0 BL_36 BL__36 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI38_2 BL_36 BL__36 WL WL VSS VDD RA1SHD4096X32CCP
XI39_0 BL_37 BL__37 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI39_2 BL_37 BL__37 WL WL VSS VDD RA1SHD4096X32CCP
XI3_0 BL_2 BL__2 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI3_2 BL_2 BL__2 WL WL VSS VDD RA1SHD4096X32CCG
XI40_0 BL_38 BL__38 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI40_2 BL_38 BL__38 WL WL VSS VDD RA1SHD4096X32CCG
XI41_0 BL_39 BL__39 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI41_2 BL_39 BL__39 WL WL VSS VDD RA1SHD4096X32CCG
XI42_0 BL_40 BL__40 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI42_2 BL_40 BL__40 WL WL VSS VDD RA1SHD4096X32CCP
XI43_0 BL_41 BL__41 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI43_2 BL_41 BL__41 WL WL VSS VDD RA1SHD4096X32CCP
XI44_0 BL_42 BL__42 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI44_2 BL_42 BL__42 WL WL VSS VDD RA1SHD4096X32CCG
XI45_0 BL_43 BL__43 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI45_2 BL_43 BL__43 WL WL VSS VDD RA1SHD4096X32CCG
XI46_0 BL_44 BL__44 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI46_2 BL_44 BL__44 WL WL VSS VDD RA1SHD4096X32CCP
XI47_0 BL_45 BL__45 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI47_2 BL_45 BL__45 WL WL VSS VDD RA1SHD4096X32CCP
XI48_0 BL_46 BL__46 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI48_2 BL_46 BL__46 WL WL VSS VDD RA1SHD4096X32CCG
XI49_0 BL_47 BL__47 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI49_2 BL_47 BL__47 WL WL VSS VDD RA1SHD4096X32CCG
XI4_0 BL_3 BL__3 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI4_2 BL_3 BL__3 WL WL VSS VDD RA1SHD4096X32CCG
XI50_0 BL_48 BL__48 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI50_2 BL_48 BL__48 WL WL VSS VDD RA1SHD4096X32CCP
XI51_0 BL_49 BL__49 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI51_2 BL_49 BL__49 WL WL VSS VDD RA1SHD4096X32CCP
XI52_0 BL_50 BL__50 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI52_2 BL_50 BL__50 WL WL VSS VDD RA1SHD4096X32CCG
XI53_0 BL_51 BL__51 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI53_2 BL_51 BL__51 WL WL VSS VDD RA1SHD4096X32CCG
XI54_0 BL_52 BL__52 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI54_2 BL_52 BL__52 WL WL VSS VDD RA1SHD4096X32CCP
XI55_0 BL_53 BL__53 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI55_2 BL_53 BL__53 WL WL VSS VDD RA1SHD4096X32CCP
XI56_0 BL_54 BL__54 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI56_2 BL_54 BL__54 WL WL VSS VDD RA1SHD4096X32CCG
XI57_0 BL_55 BL__55 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI57_2 BL_55 BL__55 WL WL VSS VDD RA1SHD4096X32CCG
XI58_0 BL_56 BL__56 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI58_2 BL_56 BL__56 WL WL VSS VDD RA1SHD4096X32CCP
XI59_0 BL_57 BL__57 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI59_2 BL_57 BL__57 WL WL VSS VDD RA1SHD4096X32CCP
XI5_0 BL_4 BL__4 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI5_2 BL_4 BL__4 WL WL VSS VDD RA1SHD4096X32CCP
XI60_0 BL_58 BL__58 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI60_2 BL_58 BL__58 WL WL VSS VDD RA1SHD4096X32CCG
XI61_0 BL_59 BL__59 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI61_2 BL_59 BL__59 WL WL VSS VDD RA1SHD4096X32CCG
XI62_0 BL_60 BL__60 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI62_2 BL_60 BL__60 WL WL VSS VDD RA1SHD4096X32CCP
XI63_0 BL_61 BL__61 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI63_2 BL_61 BL__61 WL WL VSS VDD RA1SHD4096X32CCP
XI64_0 BL_62 BL__62 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI64_2 BL_62 BL__62 WL WL VSS VDD RA1SHD4096X32CCG
XI66_0 BL_63 BL__63 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI66_2 BL_63 BL__63 WL WL VSS VDD RA1SHD4096X32CCG
XI67_0 BL_64 BL__64 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI67_2 BL_64 BL__64 WL WL VSS VDD RA1SHD4096X32CCP
XI68_0 BL_65 BL__65 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI68_2 BL_65 BL__65 WL WL VSS VDD RA1SHD4096X32CCP
XI69_0 BL_66 BL__66 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI69_2 BL_66 BL__66 WL WL VSS VDD RA1SHD4096X32CCG
XI6_0 BL_5 BL__5 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI6_2 BL_5 BL__5 WL WL VSS VDD RA1SHD4096X32CCP
XI70_0 BL_67 BL__67 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI70_2 BL_67 BL__67 WL WL VSS VDD RA1SHD4096X32CCG
XI71_0 BL_68 BL__68 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI71_2 BL_68 BL__68 WL WL VSS VDD RA1SHD4096X32CCP
XI72_0 BL_69 BL__69 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI72_2 BL_69 BL__69 WL WL VSS VDD RA1SHD4096X32CCP
XI73_0 BL_70 BL__70 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI73_2 BL_70 BL__70 WL WL VSS VDD RA1SHD4096X32CCG
XI74_0 BL_71 BL__71 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI74_2 BL_71 BL__71 WL WL VSS VDD RA1SHD4096X32CCG
XI75_0 BL_72 BL__72 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI75_2 BL_72 BL__72 WL WL VSS VDD RA1SHD4096X32CCP
XI76_0 BL_73 BL__73 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI76_2 BL_73 BL__73 WL WL VSS VDD RA1SHD4096X32CCP
XI77_0 BL_74 BL__74 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI77_2 BL_74 BL__74 WL WL VSS VDD RA1SHD4096X32CCG
XI78_0 BL_75 BL__75 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI78_2 BL_75 BL__75 WL WL VSS VDD RA1SHD4096X32CCG
XI79_0 BL_76 BL__76 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI79_2 BL_76 BL__76 WL WL VSS VDD RA1SHD4096X32CCP
XI7_0 BL_6 BL__6 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI7_2 BL_6 BL__6 WL WL VSS VDD RA1SHD4096X32CCG
XI80_0 BL_77 BL__77 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI80_2 BL_77 BL__77 WL WL VSS VDD RA1SHD4096X32CCP
XI81_0 BL_78 BL__78 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI81_2 BL_78 BL__78 WL WL VSS VDD RA1SHD4096X32CCG
XI82_0 BL_79 BL__79 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI82_2 BL_79 BL__79 WL WL VSS VDD RA1SHD4096X32CCG
XI83_0 BL_80 BL__80 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI83_2 BL_80 BL__80 WL WL VSS VDD RA1SHD4096X32CCP
XI84_0 BL_81 BL__81 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI84_2 BL_81 BL__81 WL WL VSS VDD RA1SHD4096X32CCP
XI85_0 BL_82 BL__82 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI85_2 BL_82 BL__82 WL WL VSS VDD RA1SHD4096X32CCG
XI86_0 BL_83 BL__83 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI86_2 BL_83 BL__83 WL WL VSS VDD RA1SHD4096X32CCG
XI87_0 BL_84 BL__84 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI87_2 BL_84 BL__84 WL WL VSS VDD RA1SHD4096X32CCP
XI88_0 BL_85 BL__85 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI88_2 BL_85 BL__85 WL WL VSS VDD RA1SHD4096X32CCP
XI89_0 BL_86 BL__86 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI89_2 BL_86 BL__86 WL WL VSS VDD RA1SHD4096X32CCG
XI8_0 BL_7 BL__7 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI8_2 BL_7 BL__7 WL WL VSS VDD RA1SHD4096X32CCG
XI90_0 BL_87 BL__87 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI90_2 BL_87 BL__87 WL WL VSS VDD RA1SHD4096X32CCG
XI91_0 BL_88 BL__88 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI91_2 BL_88 BL__88 WL WL VSS VDD RA1SHD4096X32CCP
XI92_0 BL_89 BL__89 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI92_2 BL_89 BL__89 WL WL VSS VDD RA1SHD4096X32CCP
XI93_0 BL_90 BL__90 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI93_2 BL_90 BL__90 WL WL VSS VDD RA1SHD4096X32CCG
XI94_0 BL_91 BL__91 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI94_2 BL_91 BL__91 WL WL VSS VDD RA1SHD4096X32CCG
XI95_0 BL_92 BL__92 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI95_2 BL_92 BL__92 WL WL VSS VDD RA1SHD4096X32CCP
XI96_0 BL_93 BL__93 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI96_2 BL_93 BL__93 WL WL VSS VDD RA1SHD4096X32CCP
XI97_0 BL_94 BL__94 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI97_2 BL_94 BL__94 WL WL VSS VDD RA1SHD4096X32CCG
XI99_0 BL_95 BL__95 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWG
XI99_2 BL_95 BL__95 WL WL VSS VDD RA1SHD4096X32CCG
XI9_0 BL_8 BL__8 MWLB MWLB MWLB MWLB VSS VDD RA1SHD4096X32CCMWP
XI9_2 BL_8 BL__8 WL WL VSS VDD RA1SHD4096X32CCP
.ENDS RA1SHD4096X32MODEL_ROW_16
****
.SUBCKT RA1SHD4096X32WD G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32WD: 30 flat devices **
m1 N25 RSWN0 GTP VDD P L=0.18U W=2.08U
m10 WL0 WL0_EN_ VSS VSS N L=0.18U W=15.71U
m11 N24 RSWN1 GTP VDD P L=0.18U W=2.08U
m12 N24 WLI1 GTP VSS N L=0.18U W=2.08U
m13 N33 G0 VSS VSS N L=0.18U W=1.73U
m14 N34 G1 N33 VSS N L=0.18U W=1.73U
m15 RSWN1 G2_W1 N34 VSS N L=0.18U W=1.73U
m16 RSWN1 G0 VDD VDD P L=0.18U W=1.35U
m17 RSWN1 G2_W1 VDD VDD P L=0.18U W=1.35U
m18 RSWN1 G1 VDD VDD P L=0.18U W=1.35U
m19 WL1 WL1_EN_ VDD VDD P L=0.18U W=30.96U
m2 N25 WLI0 GTP VSS N L=0.18U W=2.08U
m20 WL1 WL1_EN_ VSS VSS N L=0.18U W=15.71U
m21 WLI1 RSWN1 VDD VDD P L=0.18U W=0.61U
m22 WLI1 RSWN1 VSS VSS N L=0.18U W=0.29U
m23 WLI0 RSWN0 VDD VDD P L=0.18U W=0.61U
m24 WLI0 RSWN0 VSS VSS N L=0.18U W=0.29U
m25 N24 RSWN1 VSS VSS N L=0.18U W=2.08U
m26 N25 RSWN0 VSS VSS N L=0.18U W=2.08U
m27 WL1_EN_ N24 VDD VDD P L=0.18U W=14.22U
m28 WL1_EN_ N24 VSS VSS N L=0.18U W=6.66U
m29 WL0_EN_ N25 VDD VDD P L=0.18U W=14.22U
m3 N26 G0 VSS VSS N L=0.18U W=1.73U
m30 WL0_EN_ N25 VSS VSS N L=0.18U W=6.66U
m4 N27 G1 N26 VSS N L=0.18U W=1.73U
m5 RSWN0 G2_W0 N27 VSS N L=0.18U W=1.73U
m6 RSWN0 G0 VDD VDD P L=0.18U W=1.35U
m7 RSWN0 G2_W0 VDD VDD P L=0.18U W=1.35U
m8 RSWN0 G1 VDD VDD P L=0.18U W=1.35U
m9 WL0 WL0_EN_ VDD VDD P L=0.18U W=30.96U
.ENDS RA1SHD4096X32WD
****
.SUBCKT RA1SHD4096X32WD3 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32WD3: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32WD
.ENDS RA1SHD4096X32WD3
****
.SUBCKT RA1SHD4096X32ROW_FILLER3 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP0_2
+  XP0_3 XP1 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32ROW_FILLER3: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32WD3
.ENDS RA1SHD4096X32ROW_FILLER3
****
.SUBCKT RA1SHD4096X32WD0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32WD0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32WD
.ENDS RA1SHD4096X32WD0
****
.SUBCKT RA1SHD4096X32ROW_8 G0 G1 G1B GTP WL0 WL1 XP0 XP0F XP0F_0 XP0F_1 XP0F_2
+  XP0_0 XP1 XP1F XP1F_0 XP1F_1 XP1F_2 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32ROW_8: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32WD0
.ENDS RA1SHD4096X32ROW_8
****
.SUBCKT RA1SHD4096X32WD1 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32WD1: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32WD
.ENDS RA1SHD4096X32WD1
****
.SUBCKT RA1SHD4096X32ROW_FILLER1 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP0_2
+  XP0_3 XP1 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32ROW_FILLER1: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32WD1
.ENDS RA1SHD4096X32ROW_FILLER1
****
.SUBCKT RA1SHD4096X32WD2 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32WD2: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32WD
.ENDS RA1SHD4096X32WD2
****
.SUBCKT RA1SHD4096X32ROW_FILLER2 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP0_2
+  XP0_3 XP1 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32ROW_FILLER2: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32WD2
.ENDS RA1SHD4096X32ROW_FILLER2
****
.SUBCKT RA1SHD4096X32MWD GTP MBL MBL_ MWL XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32MWD: 9 flat devices **
m1 MWL N15 VDD VDD P L=0.18U W=30.96U
m2 MWL N15 VSS VSS N L=0.18U W=15.71U
m3 N15 N18 VDD VDD P L=0.18U W=16.51U
m4 N15 N18 VSS VSS N L=0.18U W=7.73U
m5 MBL GTP VDD VDD P L=0.18U W=15.35U
m6 MBL_ GTP VDD VDD P L=0.18U W=15.35U
m7 MBL GTP MBL_ VDD P L=0.18U W=15.35U
m8 N18 VSS GTP VDD P L=0.35U W=2U
m9 N18 VDD GTP VSS N L=0.35U W=2U
.ENDS RA1SHD4096X32MWD
****
.SUBCKT RA1SHD4096X32ROW_TOP G0F G1F GTP MBL MBL_ MWL XP0 XP0F XP0_0 XP0_1
+  XP0_2 XP0_3 XP1 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32ROW_TOP: 9 flat devices **
XI6_0 GTP MBL MBL_ MWL XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD4096X32MWD
.ENDS RA1SHD4096X32ROW_TOP
****
.SUBCKT RA1SHD4096X32ROW_64 G0 G0B G1 G1B GTP WL0 WL1 XP0F XP0F_0 XP0F_1
+  XP0F_2 XP0F_3 XP0F_4 XP1F XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP1F_4 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32ROW_64: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32WD0
.ENDS RA1SHD4096X32ROW_64
****
.SUBCKT RA1SHD4096X32HWDB G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32HWDB: 30 flat devices **
m1 N25 WD_I0-RSWN0 GTP VDD P L=0.18U W=2.08U
m10 WL0 WD_I0-WL0_EN_ VSS VSS N L=0.18U W=15.71U
m11 N24 WD_I0-RSWN1 GTP VDD P L=0.18U W=2.08U
m12 N24 WD_I0-WLI1 GTP VSS N L=0.18U W=2.08U
m13 N33 G0 VSS VSS N L=0.18U W=1.73U
m14 N34 G1 N33 VSS N L=0.18U W=1.73U
m15 WD_I0-RSWN1 G2_W1 N34 VSS N L=0.18U W=1.73U
m16 WD_I0-RSWN1 G0 VDD VDD P L=0.18U W=1.35U
m17 WD_I0-RSWN1 G2_W1 VDD VDD P L=0.18U W=1.35U
m18 WD_I0-RSWN1 G1 VDD VDD P L=0.18U W=1.35U
m19 WL1 WD_I0-WL1_EN_ VDD VDD P L=0.18U W=30.96U
m2 N25 WD_I0-WLI0 GTP VSS N L=0.18U W=2.08U
m20 WL1 WD_I0-WL1_EN_ VSS VSS N L=0.18U W=15.71U
m21 WD_I0-WLI1 WD_I0-RSWN1 VDD VDD P L=0.18U W=0.61U
m22 WD_I0-WLI1 WD_I0-RSWN1 VSS VSS N L=0.18U W=0.29U
m23 WD_I0-WLI0 WD_I0-RSWN0 VDD VDD P L=0.18U W=0.61U
m24 WD_I0-WLI0 WD_I0-RSWN0 VSS VSS N L=0.18U W=0.29U
m25 N24 WD_I0-RSWN1 VSS VSS N L=0.18U W=2.08U
m26 N25 WD_I0-RSWN0 VSS VSS N L=0.18U W=2.08U
m27 WD_I0-WL1_EN_ N24 VDD VDD P L=0.18U W=14.22U
m28 WD_I0-WL1_EN_ N24 VSS VSS N L=0.18U W=6.66U
m29 WD_I0-WL0_EN_ N25 VDD VDD P L=0.18U W=14.22U
m3 N26 G0 VSS VSS N L=0.18U W=1.73U
m30 WD_I0-WL0_EN_ N25 VSS VSS N L=0.18U W=6.66U
m4 N27 G1 N26 VSS N L=0.18U W=1.73U
m5 WD_I0-RSWN0 G2_W0 N27 VSS N L=0.18U W=1.73U
m6 WD_I0-RSWN0 G0 VDD VDD P L=0.18U W=1.35U
m7 WD_I0-RSWN0 G2_W0 VDD VDD P L=0.18U W=1.35U
m8 WD_I0-RSWN0 G1 VDD VDD P L=0.18U W=1.35U
m9 WL0 WD_I0-WL0_EN_ VDD VDD P L=0.18U W=30.96U
.ENDS RA1SHD4096X32HWDB
****
.SUBCKT RA1SHD4096X32HWDB0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32HWDB0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32HWDB
.ENDS RA1SHD4096X32HWDB0
****
.SUBCKT RA1SHD4096X32ROW_BOTTOM G0 G1 GTP WL0 WL1 XP0F XP0F_0 XP0F_1 XP0F_2
+  XP0F_3 XP0F_4 XP1F XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP1F_4 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32ROW_BOTTOM: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32HWDB0
.ENDS RA1SHD4096X32ROW_BOTTOM
****
.SUBCKT RA1SHD4096X32WORD_ROWS GTP MBL MBL_ MWL WL0 WL0_0 WL0_1 WL0_2 WL0_3
+  WL0_4 WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11 WL0_12 WL0_13 WL0_14
+  WL0_15 WL0_16 WL0_17 WL0_18 WL0_19 WL0_20 WL0_21 WL0_22 WL0_23 WL0_24
+  WL0_25 WL0_26 WL0_27 WL0_28 WL0_29 WL0_30 WL0_31 WL0_32 WL0_33 WL0_34
+  WL0_35 WL0_36 WL0_37 WL0_38 WL0_39 WL0_40 WL0_41 WL0_42 WL0_43 WL0_44
+  WL0_45 WL0_46 WL0_47 WL0_48 WL0_49 WL0_50 WL0_51 WL0_52 WL0_53 WL0_54
+  WL0_55 WL0_56 WL0_57 WL0_58 WL0_59 WL0_60 WL0_61 WL0_62 WL0_63 WL0_64
+  WL0_65 WL0_66 WL0_67 WL0_68 WL0_69 WL0_70 WL0_71 WL0_72 WL0_73 WL0_74
+  WL0_75 WL0_76 WL0_77 WL0_78 WL0_79 WL0_80 WL0_81 WL0_82 WL0_83 WL0_84
+  WL0_85 WL0_86 WL0_87 WL0_88 WL0_89 WL0_90 WL0_91 WL0_92 WL0_93 WL0_94
+  WL0_95 WL0_96 WL0_97 WL0_98 WL0_99 WL0_100 WL0_101 WL0_102 WL0_103 WL0_104
+  WL0_105 WL0_106 WL0_107 WL0_108 WL0_109 WL0_110 WL0_111 WL0_112 WL0_113
+  WL0_114 WL0_115 WL0_116 WL0_117 WL0_118 WL0_119 WL0_120 WL0_121 WL0_122
+  WL0_123 WL0_124 WL0_125 WL0_126 WL1 WL1_0 WL1_1 WL1_2 WL1_3 WL1_4 WL1_5
+  WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11 WL1_12 WL1_13 WL1_14 WL1_15 WL1_16
+  WL1_17 WL1_18 WL1_19 WL1_20 WL1_21 WL1_22 WL1_23 WL1_24 WL1_25 WL1_26
+  WL1_27 WL1_28 WL1_29 WL1_30 WL1_31 WL1_32 WL1_33 WL1_34 WL1_35 WL1_36
+  WL1_37 WL1_38 WL1_39 WL1_40 WL1_41 WL1_42 WL1_43 WL1_44 WL1_45 WL1_46
+  WL1_47 WL1_48 WL1_49 WL1_50 WL1_51 WL1_52 WL1_53 WL1_54 WL1_55 WL1_56
+  WL1_57 WL1_58 WL1_59 WL1_60 WL1_61 WL1_62 WL1_63 WL1_64 WL1_65 WL1_66
+  WL1_67 WL1_68 WL1_69 WL1_70 WL1_71 WL1_72 WL1_73 WL1_74 WL1_75 WL1_76
+  WL1_77 WL1_78 WL1_79 WL1_80 WL1_81 WL1_82 WL1_83 WL1_84 WL1_85 WL1_86
+  WL1_87 WL1_88 WL1_89 WL1_90 WL1_91 WL1_92 WL1_93 WL1_94 WL1_95 WL1_96
+  WL1_97 WL1_98 WL1_99 WL1_100 WL1_101 WL1_102 WL1_103 WL1_104 WL1_105
+  WL1_106 WL1_107 WL1_108 WL1_109 WL1_110 WL1_111 WL1_112 WL1_113 WL1_114
+  WL1_115 WL1_116 WL1_117 WL1_118 WL1_119 WL1_120 WL1_121 WL1_122 WL1_123
+  WL1_124 WL1_125 WL1_126 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1 XP1_0 XP1_1
+  XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD4096X32WORD_ROWS: 3849 flat devices **
XI0_0 XP0_0 XP0_4 GTP WL0 WL1 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_BOTTOM
XI0_1 XP0_0 XP0_4 GTP WL0_0 WL1_0 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_10 XP0_0 XP0_3 GTP WL0_9 WL1_9 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_100 XP1 XP1_4 XP0_4 GTP WL0_99 WL1_99 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_101 XP1 XP1_4 GTP WL0_100 WL1_100 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_102 XP1 XP1_4 GTP WL0_101 WL1_101 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_103 XP1 XP1_4 GTP WL0_102 WL1_102 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_104 XP1 XP0_3 XP1_4 GTP WL0_103 WL1_103 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_105 XP1 XP0_3 GTP WL0_104 WL1_104 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_106 XP1 XP0_3 GTP WL0_105 WL1_105 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_107 XP1 XP0_3 GTP WL0_106 WL1_106 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_108 XP1 XP1_3 XP0_3 GTP WL0_107 WL1_107 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_109 XP1 XP1_3 GTP WL0_108 WL1_108 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_11 XP0_0 XP0_3 GTP WL0_10 WL1_10 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_110 XP1 XP1_3 GTP WL0_109 WL1_109 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_111 XP1 XP1_3 GTP WL0_110 WL1_110 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_112 XP1 XP0_2 XP1_3 GTP WL0_111 WL1_111 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_113 XP1 XP0_2 GTP WL0_112 WL1_112 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_114 XP1 XP0_2 GTP WL0_113 WL1_113 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_115 XP1 XP0_2 GTP WL0_114 WL1_114 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_116 XP1 XP1_2 XP0_2 GTP WL0_115 WL1_115 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_117 XP1 XP1_2 GTP WL0_116 WL1_116 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_118 XP1 XP1_2 GTP WL0_117 WL1_117 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_119 XP1 XP1_2 GTP WL0_118 WL1_118 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_12 XP0_0 XP1_3 XP0_3 GTP WL0_11 WL1_11 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_120 XP1 XP0_1 XP1_2 GTP WL0_119 WL1_119 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_121 XP1 XP0_1 GTP WL0_120 WL1_120 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_122 XP1 XP0_1 GTP WL0_121 WL1_121 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_123 XP1 XP0_1 GTP WL0_122 WL1_122 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_124 XP1 XP1_1 XP0_1 GTP WL0_123 WL1_123 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_125 XP1 XP1_1 GTP WL0_124 WL1_124 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_126 XP1 XP1_1 GTP WL0_125 WL1_125 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_127 XP1 XP1_1 GTP WL0_126 WL1_126 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_128 XP1 XP1_1 GTP MBL MBL_ MWL XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_TOP
XI0_13 XP0_0 XP1_3 GTP WL0_12 WL1_12 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_14 XP0_0 XP1_3 GTP WL0_13 WL1_13 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_15 XP0_0 XP1_3 GTP WL0_14 WL1_14 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_16 XP0_0 XP0_2 XP1_3 GTP WL0_15 WL1_15 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_17 XP0_0 XP0_2 GTP WL0_16 WL1_16 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_18 XP0_0 XP0_2 GTP WL0_17 WL1_17 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_19 XP0_0 XP0_2 GTP WL0_18 WL1_18 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_2 XP0_0 XP0_4 GTP WL0_1 WL1_1 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_20 XP0_0 XP1_2 XP0_2 GTP WL0_19 WL1_19 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_21 XP0_0 XP1_2 GTP WL0_20 WL1_20 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_22 XP0_0 XP1_2 GTP WL0_21 WL1_21 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_23 XP0_0 XP1_2 GTP WL0_22 WL1_22 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_24 XP0_0 XP0_1 XP1_2 GTP WL0_23 WL1_23 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_25 XP0_0 XP0_1 GTP WL0_24 WL1_24 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_26 XP0_0 XP0_1 GTP WL0_25 WL1_25 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_27 XP0_0 XP0_1 GTP WL0_26 WL1_26 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_28 XP0_0 XP1_1 XP0_1 GTP WL0_27 WL1_27 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_29 XP0_0 XP1_1 GTP WL0_28 WL1_28 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_3 XP0_0 XP0_4 GTP WL0_2 WL1_2 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER3
XI0_30 XP0_0 XP1_1 GTP WL0_29 WL1_29 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_31 XP0_0 XP1_1 GTP WL0_30 WL1_30 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_32 XP1_0 XP0_0 XP0_4 XP1_1 GTP WL0_31 WL1_31 XP0 XP0_0 XP0_1 XP0_2 XP0_3
+  XP0_4 XP1 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD4096X32ROW_64
XI0_33 XP1_0 XP0_4 GTP WL0_32 WL1_32 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_34 XP1_0 XP0_4 GTP WL0_33 WL1_33 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_35 XP1_0 XP0_4 GTP WL0_34 WL1_34 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_36 XP1_0 XP1_4 XP0_4 GTP WL0_35 WL1_35 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_37 XP1_0 XP1_4 GTP WL0_36 WL1_36 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_38 XP1_0 XP1_4 GTP WL0_37 WL1_37 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_39 XP1_0 XP1_4 GTP WL0_38 WL1_38 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_4 XP0_0 XP1_4 XP0_4 GTP WL0_3 WL1_3 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0 XP1
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_40 XP1_0 XP0_3 XP1_4 GTP WL0_39 WL1_39 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_41 XP1_0 XP0_3 GTP WL0_40 WL1_40 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_42 XP1_0 XP0_3 GTP WL0_41 WL1_41 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_43 XP1_0 XP0_3 GTP WL0_42 WL1_42 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_44 XP1_0 XP1_3 XP0_3 GTP WL0_43 WL1_43 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_45 XP1_0 XP1_3 GTP WL0_44 WL1_44 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_46 XP1_0 XP1_3 GTP WL0_45 WL1_45 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_47 XP1_0 XP1_3 GTP WL0_46 WL1_46 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_48 XP1_0 XP0_2 XP1_3 GTP WL0_47 WL1_47 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_49 XP1_0 XP0_2 GTP WL0_48 WL1_48 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_5 XP0_0 XP1_4 GTP WL0_4 WL1_4 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_50 XP1_0 XP0_2 GTP WL0_49 WL1_49 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_51 XP1_0 XP0_2 GTP WL0_50 WL1_50 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_52 XP1_0 XP1_2 XP0_2 GTP WL0_51 WL1_51 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_53 XP1_0 XP1_2 GTP WL0_52 WL1_52 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_54 XP1_0 XP1_2 GTP WL0_53 WL1_53 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_55 XP1_0 XP1_2 GTP WL0_54 WL1_54 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_56 XP1_0 XP0_1 XP1_2 GTP WL0_55 WL1_55 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_57 XP1_0 XP0_1 GTP WL0_56 WL1_56 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_58 XP1_0 XP0_1 GTP WL0_57 WL1_57 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_59 XP1_0 XP0_1 GTP WL0_58 WL1_58 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_6 XP0_0 XP1_4 GTP WL0_5 WL1_5 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_60 XP1_0 XP1_1 XP0_1 GTP WL0_59 WL1_59 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0
+  XP1 XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_61 XP1_0 XP1_1 GTP WL0_60 WL1_60 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER1
XI0_62 XP1_0 XP1_1 GTP WL0_61 WL1_61 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER2
XI0_63 XP1_0 XP1_1 GTP WL0_62 WL1_62 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_4 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_FILLER3
XI0_64 XP0 XP1_0 XP0_4 XP1_1 GTP WL0_63 WL1_63 XP0 XP0_0 XP0_1 XP0_2 XP0_3
+  XP0_4 XP1 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD4096X32ROW_64
XI0_65 XP0 XP0_4 GTP WL0_64 WL1_64 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_66 XP0 XP0_4 GTP WL0_65 WL1_65 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_67 XP0 XP0_4 GTP WL0_66 WL1_66 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER3
XI0_68 XP0 XP1_4 XP0_4 GTP WL0_67 WL1_67 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0 XP1
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_69 XP0 XP1_4 GTP WL0_68 WL1_68 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_7 XP0_0 XP1_4 GTP WL0_6 WL1_6 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER3
XI0_70 XP0 XP1_4 GTP WL0_69 WL1_69 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_71 XP0 XP1_4 GTP WL0_70 WL1_70 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER3
XI0_72 XP0 XP0_3 XP1_4 GTP WL0_71 WL1_71 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0 XP1
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_73 XP0 XP0_3 GTP WL0_72 WL1_72 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_74 XP0 XP0_3 GTP WL0_73 WL1_73 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_75 XP0 XP0_3 GTP WL0_74 WL1_74 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER3
XI0_76 XP0 XP1_3 XP0_3 GTP WL0_75 WL1_75 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0 XP1
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_77 XP0 XP1_3 GTP WL0_76 WL1_76 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_78 XP0 XP1_3 GTP WL0_77 WL1_77 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_79 XP0 XP1_3 GTP WL0_78 WL1_78 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER3
XI0_8 XP0_0 XP0_3 XP1_4 GTP WL0_7 WL1_7 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0 XP1
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_80 XP0 XP0_2 XP1_3 GTP WL0_79 WL1_79 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0 XP1
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_81 XP0 XP0_2 GTP WL0_80 WL1_80 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_82 XP0 XP0_2 GTP WL0_81 WL1_81 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_83 XP0 XP0_2 GTP WL0_82 WL1_82 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER3
XI0_84 XP0 XP1_2 XP0_2 GTP WL0_83 WL1_83 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0 XP1
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_85 XP0 XP1_2 GTP WL0_84 WL1_84 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_86 XP0 XP1_2 GTP WL0_85 WL1_85 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_87 XP0 XP1_2 GTP WL0_86 WL1_86 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER3
XI0_88 XP0 XP0_1 XP1_2 GTP WL0_87 WL1_87 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0 XP1
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_89 XP0 XP0_1 GTP WL0_88 WL1_88 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_9 XP0_0 XP0_3 GTP WL0_8 WL1_8 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_90 XP0 XP0_1 GTP WL0_89 WL1_89 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_91 XP0 XP0_1 GTP WL0_90 WL1_90 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER3
XI0_92 XP0 XP1_1 XP0_1 GTP WL0_91 WL1_91 XP0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_0 XP1
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_8
XI0_93 XP0 XP1_1 GTP WL0_92 WL1_92 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_94 XP0 XP1_1 GTP WL0_93 WL1_93 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_95 XP0 XP1_1 GTP WL0_94 WL1_94 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER3
XI0_96 XP1 XP0 XP0_4 XP1_1 GTP WL0_95 WL1_95 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD4096X32ROW_64
XI0_97 XP1 XP0_4 GTP WL0_96 WL1_96 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER1
XI0_98 XP1 XP0_4 GTP WL0_97 WL1_97 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER2
XI0_99 XP1 XP0_4 GTP WL0_98 WL1_98 XP0 XP0_4 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_4
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD4096X32ROW_FILLER3
.ENDS RA1SHD4096X32WORD_ROWS
****
.SUBCKT RA1SHD4096X32HCKA A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32HCKA: 9 flat devices **
m1 CK-SRCFEED CK-GTPNSRC VSS VSS N L=0.18U W=29.52U
m2 GTPN CLK CK-GTPFEED VSS N L=0.18U W=9.84U
m3 GTPN RST VDD VDD P L=0.18U W=19.12U
m4 AGTP GTPN VDD VDD P L=0.18U W=42.64U
m5 AGTP GTPN VSS VSS N L=0.18U W=20U
m6 CK-GTPNSRC GSRCN VDD VDD P L=0.18U W=4.48U
m7 CK-GTPNSRC GSRCN VSS VSS N L=0.18U W=2.52U
m8 CK-GTPFEED CLK CK-SRCFEED VSS N L=0.18U W=9.84U
m9 CK-GTPFEED GTPN VDD VSS N L=0.18U W=2.46U
.ENDS RA1SHD4096X32HCKA
****
.SUBCKT RA1SHD4096X32CK A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32CK: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS N L=0.18U W=29.52U
m2 GTPN CLK GTPFEED VSS N L=0.18U W=9.84U
m3 GTPN RST VDD VDD P L=0.18U W=19.12U
m4 GTP GTPN VDD VDD P L=0.18U W=42.64U
m5 GTP GTPN VSS VSS N L=0.18U W=20U
m6 GTPNSRC GSRCN VDD VDD P L=0.18U W=4.48U
m7 GTPNSRC GSRCN VSS VSS N L=0.18U W=2.52U
m8 GTPFEED CLK SRCFEED VSS N L=0.18U W=9.84U
m9 GTPFEED GTPN VDD VSS N L=0.18U W=2.46U
.ENDS RA1SHD4096X32CK
****
.SUBCKT RA1SHD4096X32CLK_DRVS A0 A0_ AGTP CLK GSRCN GTP GTPN GTP_0 GTP_1 GTP_2
+  RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32CLK_DRVS: 45 flat devices **
XI0_0 A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SHD4096X32HCKA
XI1_0 A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SHD4096X32CK
XI2_0 A0 A0_ CLK GSRCN GTP_0 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD4096X32CK
XI3_0 A0 A0_ CLK GSRCN GTP_1 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD4096X32CK
XI4_0 A0 A0_ CLK GSRCN GTP_2 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD4096X32CK
.ENDS RA1SHD4096X32CLK_DRVS
****
.SUBCKT RA1SHD4096X32WING_16_RIGHT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42
+  BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54
+  BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66
+  BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78
+  BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90
+  BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102
+  BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112
+  BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122
+  BL_123 BL_124 BL_125 BL_126 BL_127 BL_128 BL_129 BL_130 BL_131 BL_132
+  BL_133 BL_134 BL_135 BL_136 BL_137 BL_138 BL_139 BL_140 BL_141 BL_142
+  BL_143 BL_144 BL_145 BL_146 BL_147 BL_148 BL_149 BL_150 BL_151 BL_152
+  BL_153 BL_154 BL_155 BL_156 BL_157 BL_158 BL_159 BL_160 BL_161 BL_162
+  BL_163 BL_164 BL_165 BL_166 BL_167 BL_168 BL_169 BL_170 BL_171 BL_172
+  BL_173 BL_174 BL_175 BL_176 BL_177 BL_178 BL_179 BL_180 BL_181 BL_182
+  BL_183 BL_184 BL_185 BL_186 BL_187 BL_188 BL_189 BL_190 BL_191 BL_192
+  BL_193 BL_194 BL_195 BL_196 BL_197 BL_198 BL_199 BL_200 BL_201 BL_202
+  BL_203 BL_204 BL_205 BL_206 BL_207 BL_208 BL_209 BL_210 BL_211 BL_212
+  BL_213 BL_214 BL_215 BL_216 BL_217 BL_218 BL_219 BL_220 BL_221 BL_222
+  BL_223 BL_224 BL_225 BL_226 BL_227 BL_228 BL_229 BL_230 BL_231 BL_232
+  BL_233 BL_234 BL_235 BL_236 BL_237 BL_238 BL_239 BL_240 BL_241 BL_242
+  BL_243 BL_244 BL_245 BL_246 BL_247 BL_248 BL_249 BL_250 BL_251 BL_252
+  BL_253 BL_254 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39
+  BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49
+  BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59
+  BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69
+  BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79
+  BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89
+  BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99
+  BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108
+  BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117
+  BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126
+  BL__127 BL__128 BL__129 BL__130 BL__131 BL__132 BL__133 BL__134 BL__135
+  BL__136 BL__137 BL__138 BL__139 BL__140 BL__141 BL__142 BL__143 BL__144
+  BL__145 BL__146 BL__147 BL__148 BL__149 BL__150 BL__151 BL__152 BL__153
+  BL__154 BL__155 BL__156 BL__157 BL__158 BL__159 BL__160 BL__161 BL__162
+  BL__163 BL__164 BL__165 BL__166 BL__167 BL__168 BL__169 BL__170 BL__171
+  BL__172 BL__173 BL__174 BL__175 BL__176 BL__177 BL__178 BL__179 BL__180
+  BL__181 BL__182 BL__183 BL__184 BL__185 BL__186 BL__187 BL__188 BL__189
+  BL__190 BL__191 BL__192 BL__193 BL__194 BL__195 BL__196 BL__197 BL__198
+  BL__199 BL__200 BL__201 BL__202 BL__203 BL__204 BL__205 BL__206 BL__207
+  BL__208 BL__209 BL__210 BL__211 BL__212 BL__213 BL__214 BL__215 BL__216
+  BL__217 BL__218 BL__219 BL__220 BL__221 BL__222 BL__223 BL__224 BL__225
+  BL__226 BL__227 BL__228 BL__229 BL__230 BL__231 BL__232 BL__233 BL__234
+  BL__235 BL__236 BL__237 BL__238 BL__239 BL__240 BL__241 BL__242 BL__243
+  BL__244 BL__245 BL__246 BL__247 BL__248 BL__249 BL__250 BL__251 BL__252
+  BL__253 BL__254 BWEN BWEN_0 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10
+  D_11 D_12 D_13 D_14 GTP GTP_0 GTP_1 OE_ Q Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW
+  STUBDW_ STUBDW_0 STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32WING_16_RIGHT: 400450 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BWEN D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR_67 STUBDR__65 STUBDR_0 STUBDR__0 STUBDW_69 STUBDW__71 STUBDW_0
+  STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_EVEN_LE16
XI10_0 A0 A0_ BL_126 BL__126 BL_125 BL_124 BL_123 BL_122 BL_121 BL_120 BL_119
+  BL_118 BL_117 BL_116 BL_115 BL_114 BL_113 BL_112 BL_111 BL__125 BL__124
+  BL__123 BL__122 BL__121 BL__120 BL__119 BL__118 BL__117 BL__116 BL__115
+  BL__114 BL__113 BL__112 BL__111 BWEN D_6 GTP GTP_0 GTP_1 OE_ Q_6 STUBDR_3
+  STUBDR__1 STUBDR_0_11 STUBDR__0_9 STUBDW_5 STUBDW__7 STUBDW_0_13
+  STUBDW__0_15 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_ODD_RO16
XI12_0 A0 A0_ BL_127 BL__127 BL_128 BL_129 BL_130 BL_131 BL_132 BL_133 BL_134
+  BL_135 BL_136 BL_137 BL_138 BL_139 BL_140 BL_141 BL_142 BL__128 BL__129
+  BL__130 BL__131 BL__132 BL__133 BL__134 BL__135 BL__136 BL__137 BL__138
+  BL__139 BL__140 BL__141 BL__142 BWEN_0 D_7 GTP GTP_0 GTP_1 OE_ Q_7
+  STUBDR_19 STUBDR__17 STUBDR_0_11 STUBDR__0_9 STUBDW_21 STUBDW__23
+  STUBDW_0_13 STUBDW__0_15 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_EVEN_LE16
XI13_0 A0 A0_ BL_158 BL__158 BL_157 BL_156 BL_155 BL_154 BL_153 BL_152 BL_151
+  BL_150 BL_149 BL_148 BL_147 BL_146 BL_145 BL_144 BL_143 BL__157 BL__156
+  BL__155 BL__154 BL__153 BL__152 BL__151 BL__150 BL__149 BL__148 BL__147
+  BL__146 BL__145 BL__144 BL__143 BWEN_0 D_8 GTP GTP_0 GTP_1 OE_ Q_8
+  STUBDR_19 STUBDR__17 STUBDR_0_27 STUBDR__0_25 STUBDW_21 STUBDW__23
+  STUBDW_0_29 STUBDW__0_31 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_ODD_M16
XI15_0 A0 A0_ BL_159 BL__159 BL_160 BL_161 BL_162 BL_163 BL_164 BL_165 BL_166
+  BL_167 BL_168 BL_169 BL_170 BL_171 BL_172 BL_173 BL_174 BL__160 BL__161
+  BL__162 BL__163 BL__164 BL__165 BL__166 BL__167 BL__168 BL__169 BL__170
+  BL__171 BL__172 BL__173 BL__174 BWEN_0 D_9 GTP GTP_0 GTP_1 OE_ Q_9
+  STUBDR_35 STUBDR__33 STUBDR_0_27 STUBDR__0_25 STUBDW_37 STUBDW__39
+  STUBDW_0_29 STUBDW__0_31 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_EVEN_M16
XI16_0 A0 A0_ BL_190 BL__190 BL_189 BL_188 BL_187 BL_186 BL_185 BL_184 BL_183
+  BL_182 BL_181 BL_180 BL_179 BL_178 BL_177 BL_176 BL_175 BL__189 BL__188
+  BL__187 BL__186 BL__185 BL__184 BL__183 BL__182 BL__181 BL__180 BL__179
+  BL__178 BL__177 BL__176 BL__175 BWEN_0 D_10 GTP GTP_0 GTP_1 OE_ Q_10
+  STUBDR_35 STUBDR__33 STUBDR_0_43 STUBDR__0_41 STUBDW_37 STUBDW__39
+  STUBDW_0_45 STUBDW__0_47 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_ODD_M16
XI18_0 A0 A0_ BL_191 BL__191 BL_192 BL_193 BL_194 BL_195 BL_196 BL_197 BL_198
+  BL_199 BL_200 BL_201 BL_202 BL_203 BL_204 BL_205 BL_206 BL__192 BL__193
+  BL__194 BL__195 BL__196 BL__197 BL__198 BL__199 BL__200 BL__201 BL__202
+  BL__203 BL__204 BL__205 BL__206 BWEN_0 D_11 GTP GTP_0 GTP_1 OE_ Q_11
+  STUBDR_51 STUBDR__49 STUBDR_0_43 STUBDR__0_41 STUBDW_53 STUBDW__55
+  STUBDW_0_45 STUBDW__0_47 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_EVEN_M16
XI19_0 A0 A0_ BL_222 BL__222 BL_221 BL_220 BL_219 BL_218 BL_217 BL_216 BL_215
+  BL_214 BL_213 BL_212 BL_211 BL_210 BL_209 BL_208 BL_207 BL__221 BL__220
+  BL__219 BL__218 BL__217 BL__216 BL__215 BL__214 BL__213 BL__212 BL__211
+  BL__210 BL__209 BL__208 BL__207 BWEN_0 D_12 GTP GTP_0 GTP_1 OE_ Q_12
+  STUBDR_51 STUBDR__49 STUBDR_0_59 STUBDR__0_57 STUBDW_53 STUBDW__55
+  STUBDW_0_61 STUBDW__0_63 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_ODD_M16
XI1_0 A0 A0_ BL_30 BL__30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL_22
+  BL_21 BL_20 BL_19 BL_18 BL_17 BL_16 BL_15 BL__29 BL__28 BL__27 BL__26
+  BL__25 BL__24 BL__23 BL__22 BL__21 BL__20 BL__19 BL__18 BL__17 BL__16
+  BL__15 BWEN D_0 GTP GTP_0 GTP_1 OE_ Q_0 STUBDR_67 STUBDR__65 STUBDR_0_75
+  STUBDR__0_73 STUBDW_69 STUBDW__71 STUBDW_0_77 STUBDW__0_79 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_ODD_M16
XI21_0 A0 A0_ BL_223 BL__223 BL_224 BL_225 BL_226 BL_227 BL_228 BL_229 BL_230
+  BL_231 BL_232 BL_233 BL_234 BL_235 BL_236 BL_237 BL_238 BL__224 BL__225
+  BL__226 BL__227 BL__228 BL__229 BL__230 BL__231 BL__232 BL__233 BL__234
+  BL__235 BL__236 BL__237 BL__238 BWEN_0 D_13 GTP GTP_0 GTP_1 OE_ Q_13
+  STUBDR_115 STUBDR__113 STUBDR_0_59 STUBDR__0_57 STUBDW_117 STUBDW__119
+  STUBDW_0_61 STUBDW__0_63 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32MCOL_EVEN_M16
XI22_0 A0 A0_ BL_254 BL__254 BL_253 BL_252 BL_251 BL_250 BL_249 BL_248 BL_247
+  BL_246 BL_245 BL_244 BL_243 BL_242 BL_241 BL_240 BL_239 BL__253 BL__252
+  BL__251 BL__250 BL__249 BL__248 BL__247 BL__246 BL__245 BL__244 BL__243
+  BL__242 BL__241 BL__240 BL__239 BWEN_0 D_14 GTP GTP_0 GTP_1 OE_ Q_14
+  STUBDR_115 STUBDR__113 STUBDR STUBDR_ STUBDW_117 STUBDW__119 STUBDW STUBDW_
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76
+  WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88
+  WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100
+  WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110
+  WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120
+  WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130
+  WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140
+  WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150
+  WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160
+  WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170
+  WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180
+  WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190
+  WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200
+  WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210
+  WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220
+  WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230
+  WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240
+  WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250
+  WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VSS VDD RA1SHD4096X32MCOL_ODD_RO16
XI3_0 A0 A0_ BL_31 BL__31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39
+  BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL__32 BL__33 BL__34 BL__35
+  BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45
+  BL__46 BWEN D_1 GTP GTP_0 GTP_1 OE_ Q_1 STUBDR_83 STUBDR__81 STUBDR_0_75
+  STUBDR__0_73 STUBDW_85 STUBDW__87 STUBDW_0_77 STUBDW__0_79 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_EVEN_M16
XI4_0 A0 A0_ BL_62 BL__62 BL_61 BL_60 BL_59 BL_58 BL_57 BL_56 BL_55 BL_54
+  BL_53 BL_52 BL_51 BL_50 BL_49 BL_48 BL_47 BL__61 BL__60 BL__59 BL__58
+  BL__57 BL__56 BL__55 BL__54 BL__53 BL__52 BL__51 BL__50 BL__49 BL__48
+  BL__47 BWEN D_2 GTP GTP_0 GTP_1 OE_ Q_2 STUBDR_83 STUBDR__81 STUBDR_0_91
+  STUBDR__0_89 STUBDW_85 STUBDW__87 STUBDW_0_93 STUBDW__0_95 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_ODD_M16
XI6_0 A0 A0_ BL_63 BL__63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71
+  BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL__64 BL__65 BL__66 BL__67
+  BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77
+  BL__78 BWEN D_3 GTP GTP_0 GTP_1 OE_ Q_3 STUBDR_99 STUBDR__97 STUBDR_0_91
+  STUBDR__0_89 STUBDW_101 STUBDW__103 STUBDW_0_93 STUBDW__0_95 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_EVEN_M16
XI7_0 A0 A0_ BL_94 BL__94 BL_93 BL_92 BL_91 BL_90 BL_89 BL_88 BL_87 BL_86
+  BL_85 BL_84 BL_83 BL_82 BL_81 BL_80 BL_79 BL__93 BL__92 BL__91 BL__90
+  BL__89 BL__88 BL__87 BL__86 BL__85 BL__84 BL__83 BL__82 BL__81 BL__80
+  BL__79 BWEN D_4 GTP GTP_0 GTP_1 OE_ Q_4 STUBDR_99 STUBDR__97 STUBDR_0_107
+  STUBDR__0_105 STUBDW_101 STUBDW__103 STUBDW_0_109 STUBDW__0_111 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_ODD_M16
XI9_0 A0 A0_ BL_95 BL__95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BWEN D_5 GTP GTP_0 GTP_1 OE_ Q_5 STUBDR_3 STUBDR__1
+  STUBDR_0_107 STUBDR__0_105 STUBDW_5 STUBDW__7 STUBDW_0_109 STUBDW__0_111 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73
+  WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85
+  WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97
+  WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108
+  WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118
+  WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128
+  WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138
+  WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148
+  WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158
+  WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168
+  WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178
+  WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188
+  WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198
+  WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208
+  WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218
+  WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228
+  WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238
+  WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248
+  WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66
+  WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78
+  WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90
+  WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102
+  WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112
+  WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122
+  WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132
+  WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142
+  WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152
+  WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162
+  WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172
+  WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182
+  WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192
+  WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202
+  WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212
+  WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222
+  WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232
+  WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242
+  WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252
+  WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32MCOL_EVEN_M16
.ENDS RA1SHD4096X32WING_16_RIGHT
****
.SUBCKT RA1SHD4096X32FLCIO A0 A0_ CLK GSRCN GTP GTPN MBL MBL_ RST YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32FLCIO: 11 flat devices **
d1 VSS GTP DN 0.3364P 2.32U
d10 VSS A0_ DN 0.3364P 2.32U
d11 VSS A0 DN 0.3364P 2.32U
d2 VSS YP0_0 DN 0.3364P 2.32U
d3 VSS YP1_0 DN 0.3364P 2.32U
d4 VSS YP0_1 DN 0.3364P 2.32U
d5 VSS YP0_2 DN 0.3364P 2.32U
d6 VSS YP0_3 DN 0.3364P 2.32U
d7 VSS YP1_1 DN 0.3364P 2.32U
d8 VSS YP1_2 DN 0.3364P 2.32U
d9 VSS YP1_3 DN 0.3364P 2.32U
.ENDS RA1SHD4096X32FLCIO
****
.SUBCKT RA1SHD4096X32FCCDR A0 A0_ GTP VD YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32FCCDR: 2 flat devices **
d2 VSS VSS DN 0.3364P 2.32U
m1 VDD VSS VD VDD P L=0.18U W=0.22U
.ENDS RA1SHD4096X32FCCDR
****
.SUBCKT RA1SHD4096X32RIGHT_CAP A0 A0_ GTP GTP_0 GTP_1 OE_ WE WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SHD4096X32RIGHT_CAP: 1560 flat devices **
XI0_0 GTP OE_ WE VSS VDD RA1SHD4096X32FCIO8
XI0_1 GTP_0 VSS VDD RA1SHD4096X32FCSA8
XI0_10 BL BL WL_6 WL_6 VSS VDD RA1SHD4096X32CCG
XI0_100 BL BL WL_96 WL_96 VSS VDD RA1SHD4096X32CCG
XI0_101 BL BL WL_97 WL_97 VSS VDD RA1SHD4096X32CCG
XI0_102 BL BL WL_98 WL_98 VSS VDD RA1SHD4096X32CCG
XI0_103 BL BL WL_99 WL_99 VSS VDD RA1SHD4096X32CCG
XI0_104 BL BL WL_100 WL_100 VSS VDD RA1SHD4096X32CCG
XI0_105 BL BL WL_101 WL_101 VSS VDD RA1SHD4096X32CCG
XI0_106 BL BL WL_102 WL_102 VSS VDD RA1SHD4096X32CCG
XI0_107 BL BL WL_103 WL_103 VSS VDD RA1SHD4096X32CCG
XI0_108 BL BL WL_104 WL_104 VSS VDD RA1SHD4096X32CCG
XI0_109 BL BL WL_105 WL_105 VSS VDD RA1SHD4096X32CCG
XI0_11 BL BL WL_7 WL_7 VSS VDD RA1SHD4096X32CCG
XI0_110 BL BL WL_106 WL_106 VSS VDD RA1SHD4096X32CCG
XI0_111 BL BL WL_107 WL_107 VSS VDD RA1SHD4096X32CCG
XI0_112 BL BL WL_108 WL_108 VSS VDD RA1SHD4096X32CCG
XI0_113 BL BL WL_109 WL_109 VSS VDD RA1SHD4096X32CCG
XI0_114 BL BL WL_110 WL_110 VSS VDD RA1SHD4096X32CCG
XI0_115 BL BL WL_111 WL_111 VSS VDD RA1SHD4096X32CCG
XI0_116 BL BL WL_112 WL_112 VSS VDD RA1SHD4096X32CCG
XI0_117 BL BL WL_113 WL_113 VSS VDD RA1SHD4096X32CCG
XI0_118 BL BL WL_114 WL_114 VSS VDD RA1SHD4096X32CCG
XI0_119 BL BL WL_115 WL_115 VSS VDD RA1SHD4096X32CCG
XI0_12 BL BL WL_8 WL_8 VSS VDD RA1SHD4096X32CCG
XI0_120 BL BL WL_116 WL_116 VSS VDD RA1SHD4096X32CCG
XI0_121 BL BL WL_117 WL_117 VSS VDD RA1SHD4096X32CCG
XI0_122 BL BL WL_118 WL_118 VSS VDD RA1SHD4096X32CCG
XI0_123 BL BL WL_119 WL_119 VSS VDD RA1SHD4096X32CCG
XI0_124 BL BL WL_120 WL_120 VSS VDD RA1SHD4096X32CCG
XI0_125 BL BL WL_121 WL_121 VSS VDD RA1SHD4096X32CCG
XI0_126 BL BL WL_122 WL_122 VSS VDD RA1SHD4096X32CCG
XI0_127 BL BL WL_123 WL_123 VSS VDD RA1SHD4096X32CCG
XI0_128 BL BL WL_124 WL_124 VSS VDD RA1SHD4096X32CCG
XI0_129 BL BL WL_125 WL_125 VSS VDD RA1SHD4096X32CCG
XI0_13 BL BL WL_9 WL_9 VSS VDD RA1SHD4096X32CCG
XI0_130 BL BL WL_126 WL_126 VSS VDD RA1SHD4096X32CCG
XI0_131 BL BL WL_127 WL_127 VSS VDD RA1SHD4096X32CCG
XI0_132 BL BL WL_128 WL_128 VSS VDD RA1SHD4096X32CCG
XI0_133 BL BL WL_129 WL_129 VSS VDD RA1SHD4096X32CCG
XI0_134 BL BL WL_130 WL_130 VSS VDD RA1SHD4096X32CCG
XI0_135 BL BL WL_131 WL_131 VSS VDD RA1SHD4096X32CCG
XI0_136 BL BL WL_132 WL_132 VSS VDD RA1SHD4096X32CCG
XI0_137 BL BL WL_133 WL_133 VSS VDD RA1SHD4096X32CCG
XI0_138 BL BL WL_134 WL_134 VSS VDD RA1SHD4096X32CCG
XI0_139 BL BL WL_135 WL_135 VSS VDD RA1SHD4096X32CCG
XI0_14 BL BL WL_10 WL_10 VSS VDD RA1SHD4096X32CCG
XI0_140 BL BL WL_136 WL_136 VSS VDD RA1SHD4096X32CCG
XI0_141 BL BL WL_137 WL_137 VSS VDD RA1SHD4096X32CCG
XI0_142 BL BL WL_138 WL_138 VSS VDD RA1SHD4096X32CCG
XI0_143 BL BL WL_139 WL_139 VSS VDD RA1SHD4096X32CCG
XI0_144 BL BL WL_140 WL_140 VSS VDD RA1SHD4096X32CCG
XI0_145 BL BL WL_141 WL_141 VSS VDD RA1SHD4096X32CCG
XI0_146 BL BL WL_142 WL_142 VSS VDD RA1SHD4096X32CCG
XI0_147 BL BL WL_143 WL_143 VSS VDD RA1SHD4096X32CCG
XI0_148 BL BL WL_144 WL_144 VSS VDD RA1SHD4096X32CCG
XI0_149 BL BL WL_145 WL_145 VSS VDD RA1SHD4096X32CCG
XI0_15 BL BL WL_11 WL_11 VSS VDD RA1SHD4096X32CCG
XI0_150 BL BL WL_146 WL_146 VSS VDD RA1SHD4096X32CCG
XI0_151 BL BL WL_147 WL_147 VSS VDD RA1SHD4096X32CCG
XI0_152 BL BL WL_148 WL_148 VSS VDD RA1SHD4096X32CCG
XI0_153 BL BL WL_149 WL_149 VSS VDD RA1SHD4096X32CCG
XI0_154 BL BL WL_150 WL_150 VSS VDD RA1SHD4096X32CCG
XI0_155 BL BL WL_151 WL_151 VSS VDD RA1SHD4096X32CCG
XI0_156 BL BL WL_152 WL_152 VSS VDD RA1SHD4096X32CCG
XI0_157 BL BL WL_153 WL_153 VSS VDD RA1SHD4096X32CCG
XI0_158 BL BL WL_154 WL_154 VSS VDD RA1SHD4096X32CCG
XI0_159 BL BL WL_155 WL_155 VSS VDD RA1SHD4096X32CCG
XI0_16 BL BL WL_12 WL_12 VSS VDD RA1SHD4096X32CCG
XI0_160 BL BL WL_156 WL_156 VSS VDD RA1SHD4096X32CCG
XI0_161 BL BL WL_157 WL_157 VSS VDD RA1SHD4096X32CCG
XI0_162 BL BL WL_158 WL_158 VSS VDD RA1SHD4096X32CCG
XI0_163 BL BL WL_159 WL_159 VSS VDD RA1SHD4096X32CCG
XI0_164 BL BL WL_160 WL_160 VSS VDD RA1SHD4096X32CCG
XI0_165 BL BL WL_161 WL_161 VSS VDD RA1SHD4096X32CCG
XI0_166 BL BL WL_162 WL_162 VSS VDD RA1SHD4096X32CCG
XI0_167 BL BL WL_163 WL_163 VSS VDD RA1SHD4096X32CCG
XI0_168 BL BL WL_164 WL_164 VSS VDD RA1SHD4096X32CCG
XI0_169 BL BL WL_165 WL_165 VSS VDD RA1SHD4096X32CCG
XI0_17 BL BL WL_13 WL_13 VSS VDD RA1SHD4096X32CCG
XI0_170 BL BL WL_166 WL_166 VSS VDD RA1SHD4096X32CCG
XI0_171 BL BL WL_167 WL_167 VSS VDD RA1SHD4096X32CCG
XI0_172 BL BL WL_168 WL_168 VSS VDD RA1SHD4096X32CCG
XI0_173 BL BL WL_169 WL_169 VSS VDD RA1SHD4096X32CCG
XI0_174 BL BL WL_170 WL_170 VSS VDD RA1SHD4096X32CCG
XI0_175 BL BL WL_171 WL_171 VSS VDD RA1SHD4096X32CCG
XI0_176 BL BL WL_172 WL_172 VSS VDD RA1SHD4096X32CCG
XI0_177 BL BL WL_173 WL_173 VSS VDD RA1SHD4096X32CCG
XI0_178 BL BL WL_174 WL_174 VSS VDD RA1SHD4096X32CCG
XI0_179 BL BL WL_175 WL_175 VSS VDD RA1SHD4096X32CCG
XI0_18 BL BL WL_14 WL_14 VSS VDD RA1SHD4096X32CCG
XI0_180 BL BL WL_176 WL_176 VSS VDD RA1SHD4096X32CCG
XI0_181 BL BL WL_177 WL_177 VSS VDD RA1SHD4096X32CCG
XI0_182 BL BL WL_178 WL_178 VSS VDD RA1SHD4096X32CCG
XI0_183 BL BL WL_179 WL_179 VSS VDD RA1SHD4096X32CCG
XI0_184 BL BL WL_180 WL_180 VSS VDD RA1SHD4096X32CCG
XI0_185 BL BL WL_181 WL_181 VSS VDD RA1SHD4096X32CCG
XI0_186 BL BL WL_182 WL_182 VSS VDD RA1SHD4096X32CCG
XI0_187 BL BL WL_183 WL_183 VSS VDD RA1SHD4096X32CCG
XI0_188 BL BL WL_184 WL_184 VSS VDD RA1SHD4096X32CCG
XI0_189 BL BL WL_185 WL_185 VSS VDD RA1SHD4096X32CCG
XI0_19 BL BL WL_15 WL_15 VSS VDD RA1SHD4096X32CCG
XI0_190 BL BL WL_186 WL_186 VSS VDD RA1SHD4096X32CCG
XI0_191 BL BL WL_187 WL_187 VSS VDD RA1SHD4096X32CCG
XI0_192 BL BL WL_188 WL_188 VSS VDD RA1SHD4096X32CCG
XI0_193 BL BL WL_189 WL_189 VSS VDD RA1SHD4096X32CCG
XI0_194 BL BL WL_190 WL_190 VSS VDD RA1SHD4096X32CCG
XI0_195 BL BL WL_191 WL_191 VSS VDD RA1SHD4096X32CCG
XI0_196 BL BL WL_192 WL_192 VSS VDD RA1SHD4096X32CCG
XI0_197 BL BL WL_193 WL_193 VSS VDD RA1SHD4096X32CCG
XI0_198 BL BL WL_194 WL_194 VSS VDD RA1SHD4096X32CCG
XI0_199 BL BL WL_195 WL_195 VSS VDD RA1SHD4096X32CCG
XI0_2 A0 A0_ GTP_1 BL YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32FCCDR
XI0_20 BL BL WL_16 WL_16 VSS VDD RA1SHD4096X32CCG
XI0_200 BL BL WL_196 WL_196 VSS VDD RA1SHD4096X32CCG
XI0_201 BL BL WL_197 WL_197 VSS VDD RA1SHD4096X32CCG
XI0_202 BL BL WL_198 WL_198 VSS VDD RA1SHD4096X32CCG
XI0_203 BL BL WL_199 WL_199 VSS VDD RA1SHD4096X32CCG
XI0_204 BL BL WL_200 WL_200 VSS VDD RA1SHD4096X32CCG
XI0_205 BL BL WL_201 WL_201 VSS VDD RA1SHD4096X32CCG
XI0_206 BL BL WL_202 WL_202 VSS VDD RA1SHD4096X32CCG
XI0_207 BL BL WL_203 WL_203 VSS VDD RA1SHD4096X32CCG
XI0_208 BL BL WL_204 WL_204 VSS VDD RA1SHD4096X32CCG
XI0_209 BL BL WL_205 WL_205 VSS VDD RA1SHD4096X32CCG
XI0_21 BL BL WL_17 WL_17 VSS VDD RA1SHD4096X32CCG
XI0_210 BL BL WL_206 WL_206 VSS VDD RA1SHD4096X32CCG
XI0_211 BL BL WL_207 WL_207 VSS VDD RA1SHD4096X32CCG
XI0_212 BL BL WL_208 WL_208 VSS VDD RA1SHD4096X32CCG
XI0_213 BL BL WL_209 WL_209 VSS VDD RA1SHD4096X32CCG
XI0_214 BL BL WL_210 WL_210 VSS VDD RA1SHD4096X32CCG
XI0_215 BL BL WL_211 WL_211 VSS VDD RA1SHD4096X32CCG
XI0_216 BL BL WL_212 WL_212 VSS VDD RA1SHD4096X32CCG
XI0_217 BL BL WL_213 WL_213 VSS VDD RA1SHD4096X32CCG
XI0_218 BL BL WL_214 WL_214 VSS VDD RA1SHD4096X32CCG
XI0_219 BL BL WL_215 WL_215 VSS VDD RA1SHD4096X32CCG
XI0_22 BL BL WL_18 WL_18 VSS VDD RA1SHD4096X32CCG
XI0_220 BL BL WL_216 WL_216 VSS VDD RA1SHD4096X32CCG
XI0_221 BL BL WL_217 WL_217 VSS VDD RA1SHD4096X32CCG
XI0_222 BL BL WL_218 WL_218 VSS VDD RA1SHD4096X32CCG
XI0_223 BL BL WL_219 WL_219 VSS VDD RA1SHD4096X32CCG
XI0_224 BL BL WL_220 WL_220 VSS VDD RA1SHD4096X32CCG
XI0_225 BL BL WL_221 WL_221 VSS VDD RA1SHD4096X32CCG
XI0_226 BL BL WL_222 WL_222 VSS VDD RA1SHD4096X32CCG
XI0_227 BL BL WL_223 WL_223 VSS VDD RA1SHD4096X32CCG
XI0_228 BL BL WL_224 WL_224 VSS VDD RA1SHD4096X32CCG
XI0_229 BL BL WL_225 WL_225 VSS VDD RA1SHD4096X32CCG
XI0_23 BL BL WL_19 WL_19 VSS VDD RA1SHD4096X32CCG
XI0_230 BL BL WL_226 WL_226 VSS VDD RA1SHD4096X32CCG
XI0_231 BL BL WL_227 WL_227 VSS VDD RA1SHD4096X32CCG
XI0_232 BL BL WL_228 WL_228 VSS VDD RA1SHD4096X32CCG
XI0_233 BL BL WL_229 WL_229 VSS VDD RA1SHD4096X32CCG
XI0_234 BL BL WL_230 WL_230 VSS VDD RA1SHD4096X32CCG
XI0_235 BL BL WL_231 WL_231 VSS VDD RA1SHD4096X32CCG
XI0_236 BL BL WL_232 WL_232 VSS VDD RA1SHD4096X32CCG
XI0_237 BL BL WL_233 WL_233 VSS VDD RA1SHD4096X32CCG
XI0_238 BL BL WL_234 WL_234 VSS VDD RA1SHD4096X32CCG
XI0_239 BL BL WL_235 WL_235 VSS VDD RA1SHD4096X32CCG
XI0_24 BL BL WL_20 WL_20 VSS VDD RA1SHD4096X32CCG
XI0_240 BL BL WL_236 WL_236 VSS VDD RA1SHD4096X32CCG
XI0_241 BL BL WL_237 WL_237 VSS VDD RA1SHD4096X32CCG
XI0_242 BL BL WL_238 WL_238 VSS VDD RA1SHD4096X32CCG
XI0_243 BL BL WL_239 WL_239 VSS VDD RA1SHD4096X32CCG
XI0_244 BL BL WL_240 WL_240 VSS VDD RA1SHD4096X32CCG
XI0_245 BL BL WL_241 WL_241 VSS VDD RA1SHD4096X32CCG
XI0_246 BL BL WL_242 WL_242 VSS VDD RA1SHD4096X32CCG
XI0_247 BL BL WL_243 WL_243 VSS VDD RA1SHD4096X32CCG
XI0_248 BL BL WL_244 WL_244 VSS VDD RA1SHD4096X32CCG
XI0_249 BL BL WL_245 WL_245 VSS VDD RA1SHD4096X32CCG
XI0_25 BL BL WL_21 WL_21 VSS VDD RA1SHD4096X32CCG
XI0_250 BL BL WL_246 WL_246 VSS VDD RA1SHD4096X32CCG
XI0_251 BL BL WL_247 WL_247 VSS VDD RA1SHD4096X32CCG
XI0_252 BL BL WL_248 WL_248 VSS VDD RA1SHD4096X32CCG
XI0_253 BL BL WL_249 WL_249 VSS VDD RA1SHD4096X32CCG
XI0_254 BL BL WL_250 WL_250 VSS VDD RA1SHD4096X32CCG
XI0_255 BL BL WL_251 WL_251 VSS VDD RA1SHD4096X32CCG
XI0_256 BL BL WL_252 WL_252 VSS VDD RA1SHD4096X32CCG
XI0_257 BL BL WL_253 WL_253 VSS VDD RA1SHD4096X32CCG
XI0_258 BL BL WL_254 WL_254 VSS VDD RA1SHD4096X32CCG
XI0_259 BL BL VSS VSS VSS VDD RA1SHD4096X32CCG
XI0_26 BL BL WL_22 WL_22 VSS VDD RA1SHD4096X32CCG
XI0_260 BL BL VSS VSS VSS VDD RA1SHD4096X32CCG
XI0_261 BL BL VSS VSS VSS VDD RA1SHD4096X32CCG
XI0_27 BL BL WL_23 WL_23 VSS VDD RA1SHD4096X32CCG
XI0_28 BL BL WL_24 WL_24 VSS VDD RA1SHD4096X32CCG
XI0_29 BL BL WL_25 WL_25 VSS VDD RA1SHD4096X32CCG
XI0_3 BL BL WL WL VSS VDD RA1SHD4096X32CCG
XI0_30 BL BL WL_26 WL_26 VSS VDD RA1SHD4096X32CCG
XI0_31 BL BL WL_27 WL_27 VSS VDD RA1SHD4096X32CCG
XI0_32 BL BL WL_28 WL_28 VSS VDD RA1SHD4096X32CCG
XI0_33 BL BL WL_29 WL_29 VSS VDD RA1SHD4096X32CCG
XI0_34 BL BL WL_30 WL_30 VSS VDD RA1SHD4096X32CCG
XI0_35 BL BL WL_31 WL_31 VSS VDD RA1SHD4096X32CCG
XI0_36 BL BL WL_32 WL_32 VSS VDD RA1SHD4096X32CCG
XI0_37 BL BL WL_33 WL_33 VSS VDD RA1SHD4096X32CCG
XI0_38 BL BL WL_34 WL_34 VSS VDD RA1SHD4096X32CCG
XI0_39 BL BL WL_35 WL_35 VSS VDD RA1SHD4096X32CCG
XI0_4 BL BL WL_0 WL_0 VSS VDD RA1SHD4096X32CCG
XI0_40 BL BL WL_36 WL_36 VSS VDD RA1SHD4096X32CCG
XI0_41 BL BL WL_37 WL_37 VSS VDD RA1SHD4096X32CCG
XI0_42 BL BL WL_38 WL_38 VSS VDD RA1SHD4096X32CCG
XI0_43 BL BL WL_39 WL_39 VSS VDD RA1SHD4096X32CCG
XI0_44 BL BL WL_40 WL_40 VSS VDD RA1SHD4096X32CCG
XI0_45 BL BL WL_41 WL_41 VSS VDD RA1SHD4096X32CCG
XI0_46 BL BL WL_42 WL_42 VSS VDD RA1SHD4096X32CCG
XI0_47 BL BL WL_43 WL_43 VSS VDD RA1SHD4096X32CCG
XI0_48 BL BL WL_44 WL_44 VSS VDD RA1SHD4096X32CCG
XI0_49 BL BL WL_45 WL_45 VSS VDD RA1SHD4096X32CCG
XI0_5 BL BL WL_1 WL_1 VSS VDD RA1SHD4096X32CCG
XI0_50 BL BL WL_46 WL_46 VSS VDD RA1SHD4096X32CCG
XI0_51 BL BL WL_47 WL_47 VSS VDD RA1SHD4096X32CCG
XI0_52 BL BL WL_48 WL_48 VSS VDD RA1SHD4096X32CCG
XI0_53 BL BL WL_49 WL_49 VSS VDD RA1SHD4096X32CCG
XI0_54 BL BL WL_50 WL_50 VSS VDD RA1SHD4096X32CCG
XI0_55 BL BL WL_51 WL_51 VSS VDD RA1SHD4096X32CCG
XI0_56 BL BL WL_52 WL_52 VSS VDD RA1SHD4096X32CCG
XI0_57 BL BL WL_53 WL_53 VSS VDD RA1SHD4096X32CCG
XI0_58 BL BL WL_54 WL_54 VSS VDD RA1SHD4096X32CCG
XI0_59 BL BL WL_55 WL_55 VSS VDD RA1SHD4096X32CCG
XI0_6 BL BL WL_2 WL_2 VSS VDD RA1SHD4096X32CCG
XI0_60 BL BL WL_56 WL_56 VSS VDD RA1SHD4096X32CCG
XI0_61 BL BL WL_57 WL_57 VSS VDD RA1SHD4096X32CCG
XI0_62 BL BL WL_58 WL_58 VSS VDD RA1SHD4096X32CCG
XI0_63 BL BL WL_59 WL_59 VSS VDD RA1SHD4096X32CCG
XI0_64 BL BL WL_60 WL_60 VSS VDD RA1SHD4096X32CCG
XI0_65 BL BL WL_61 WL_61 VSS VDD RA1SHD4096X32CCG
XI0_66 BL BL WL_62 WL_62 VSS VDD RA1SHD4096X32CCG
XI0_67 BL BL WL_63 WL_63 VSS VDD RA1SHD4096X32CCG
XI0_68 BL BL WL_64 WL_64 VSS VDD RA1SHD4096X32CCG
XI0_69 BL BL WL_65 WL_65 VSS VDD RA1SHD4096X32CCG
XI0_7 BL BL WL_3 WL_3 VSS VDD RA1SHD4096X32CCG
XI0_70 BL BL WL_66 WL_66 VSS VDD RA1SHD4096X32CCG
XI0_71 BL BL WL_67 WL_67 VSS VDD RA1SHD4096X32CCG
XI0_72 BL BL WL_68 WL_68 VSS VDD RA1SHD4096X32CCG
XI0_73 BL BL WL_69 WL_69 VSS VDD RA1SHD4096X32CCG
XI0_74 BL BL WL_70 WL_70 VSS VDD RA1SHD4096X32CCG
XI0_75 BL BL WL_71 WL_71 VSS VDD RA1SHD4096X32CCG
XI0_76 BL BL WL_72 WL_72 VSS VDD RA1SHD4096X32CCG
XI0_77 BL BL WL_73 WL_73 VSS VDD RA1SHD4096X32CCG
XI0_78 BL BL WL_74 WL_74 VSS VDD RA1SHD4096X32CCG
XI0_79 BL BL WL_75 WL_75 VSS VDD RA1SHD4096X32CCG
XI0_8 BL BL WL_4 WL_4 VSS VDD RA1SHD4096X32CCG
XI0_80 BL BL WL_76 WL_76 VSS VDD RA1SHD4096X32CCG
XI0_81 BL BL WL_77 WL_77 VSS VDD RA1SHD4096X32CCG
XI0_82 BL BL WL_78 WL_78 VSS VDD RA1SHD4096X32CCG
XI0_83 BL BL WL_79 WL_79 VSS VDD RA1SHD4096X32CCG
XI0_84 BL BL WL_80 WL_80 VSS VDD RA1SHD4096X32CCG
XI0_85 BL BL WL_81 WL_81 VSS VDD RA1SHD4096X32CCG
XI0_86 BL BL WL_82 WL_82 VSS VDD RA1SHD4096X32CCG
XI0_87 BL BL WL_83 WL_83 VSS VDD RA1SHD4096X32CCG
XI0_88 BL BL WL_84 WL_84 VSS VDD RA1SHD4096X32CCG
XI0_89 BL BL WL_85 WL_85 VSS VDD RA1SHD4096X32CCG
XI0_9 BL BL WL_5 WL_5 VSS VDD RA1SHD4096X32CCG
XI0_90 BL BL WL_86 WL_86 VSS VDD RA1SHD4096X32CCG
XI0_91 BL BL WL_87 WL_87 VSS VDD RA1SHD4096X32CCG
XI0_92 BL BL WL_88 WL_88 VSS VDD RA1SHD4096X32CCG
XI0_93 BL BL WL_89 WL_89 VSS VDD RA1SHD4096X32CCG
XI0_94 BL BL WL_90 WL_90 VSS VDD RA1SHD4096X32CCG
XI0_95 BL BL WL_91 WL_91 VSS VDD RA1SHD4096X32CCG
XI0_96 BL BL WL_92 WL_92 VSS VDD RA1SHD4096X32CCG
XI0_97 BL BL WL_93 WL_93 VSS VDD RA1SHD4096X32CCG
XI0_98 BL BL WL_94 WL_94 VSS VDD RA1SHD4096X32CCG
XI0_99 BL BL WL_95 WL_95 VSS VDD RA1SHD4096X32CCG
.ENDS RA1SHD4096X32RIGHT_CAP
****
.SUBCKT RA1SHD4096X32CCMBT MBL MBL_ TIEDOWN WL VSS VDD
** RA1SHD4096X32CCMBT: 6 flat devices **
m1 MBL TIEDOWN CORED VSS N L=0.29U W=0.22U
m2 MBL_ TIEDOWN CORED_ VSS N L=0.29U W=0.22U
m3 CORED_ CORED VDD VDD P L=0.19U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.25U
m5 CORED CORED_ VDD VDD P L=0.19U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.25U
.ENDS RA1SHD4096X32CCMBT
****
.SUBCKT RA1SHD4096X32CCMBB MBL MBL_ TIEDOWN WL VSS VDD
** RA1SHD4096X32CCMBB: 6 flat devices **
m1 MBL TIEDOWN CORED VSS N L=0.29U W=0.22U
m2 MBL_ TIEDOWN CORED_ VSS N L=0.29U W=0.22U
m3 CORED_ CORED VDD VDD P L=0.19U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.25U
m5 CORED CORED_ VDD VDD P L=0.19U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.25U
.ENDS RA1SHD4096X32CCMBB
****
.SUBCKT RA1SHD4096X32CCPDBB GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** RA1SHD4096X32CCPDBB: 5 flat devices **
m1 MBL MWL CORED VSS N L=0.29U W=0.22U
m2 MBL_ MWL N9 VSS N L=0.29U W=0.22U
m3 CORED GTP VSS VSS N L=0.18U W=0.25U
m4 N10 GTP VDD VDD P L=0.19U W=0.22U
m5 N12 CORED VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD4096X32CCPDBB
****
.SUBCKT RA1SHD4096X32CCPDT GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** RA1SHD4096X32CCPDT: 5 flat devices **
m1 MBL MWL N9 VSS N L=0.29U W=0.22U
m2 MBL_ MWL CORED_ VSS N L=0.29U W=0.22U
m3 CORED_ GTP VSS VSS N L=0.18U W=0.25U
m4 N11 GTP VDD VDD P L=0.19U W=0.22U
m5 N13 CORED_ VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD4096X32CCPDT
****
.SUBCKT RA1SHD4096X32CCPDB GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** RA1SHD4096X32CCPDB: 5 flat devices **
m1 MBL MWL CORED VSS N L=0.29U W=0.22U
m2 MBL_ MWL N9 VSS N L=0.29U W=0.22U
m3 CORED GTP VSS VSS N L=0.18U W=0.25U
m4 N10 GTP VDD VDD P L=0.19U W=0.22U
m5 N12 CORED VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD4096X32CCPDB
****
.SUBCKT RA1SHD4096X32MBLBASE GTP MBL MBL_ MWLD MWLS VSS VDD
** RA1SHD4096X32MBLBASE: 12 flat devices **
m1 N13 GTP VSS VSS N L=0.18U W=0.25U
m10 MBL MWLD NODE7 VSS N L=0.29U W=0.22U
m11 NODE8 GTP VSS VSS N L=0.18U W=0.25U
m12 MBL MWLD NODE8 VSS N L=0.29U W=0.22U
m2 MBL MWLD N13 VSS N L=0.29U W=0.22U
m3 NODE3 GTP VSS VSS N L=0.18U W=0.25U
m4 MBL MWLD NODE3 VSS N L=0.29U W=0.22U
m5 NODE4 GTP VSS VSS N L=0.18U W=0.25U
m6 MBL MWLD NODE4 VSS N L=0.29U W=0.22U
m7 NODE6 GTP VSS VSS N L=0.18U W=0.25U
m8 MBL MWLD NODE6 VSS N L=0.29U W=0.22U
m9 NODE7 GTP VSS VSS N L=0.18U W=0.25U
.ENDS RA1SHD4096X32MBLBASE
****
.SUBCKT RA1SHD4096X32MODEL_COL GTP MBL MBL_ MWLD MWLS WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76
+  WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88
+  WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100
+  WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110
+  WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120
+  WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130
+  WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140
+  WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150
+  WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160
+  WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170
+  WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180
+  WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190
+  WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200
+  WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210
+  WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220
+  WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230
+  WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240
+  WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250
+  WL_251 WL_252 WL_253 WL_254 VSS VDD
** RA1SHD4096X32MODEL_COL: 1502 flat devices **
XI0_0 MBL MBL_ VSS WL VSS VDD RA1SHD4096X32CCMBB
XI0_1 MBL_ MBL VSS WL_0 VSS VDD RA1SHD4096X32CCMBT
XI0_10 MBL MBL_ VSS WL_9 VSS VDD RA1SHD4096X32CCMBB
XI0_100 MBL MBL_ VSS WL_99 VSS VDD RA1SHD4096X32CCMBB
XI0_101 MBL_ MBL VSS WL_100 VSS VDD RA1SHD4096X32CCMBT
XI0_102 MBL MBL_ VSS WL_101 VSS VDD RA1SHD4096X32CCMBB
XI0_103 MBL_ MBL VSS WL_102 VSS VDD RA1SHD4096X32CCMBT
XI0_104 MBL MBL_ VSS WL_103 VSS VDD RA1SHD4096X32CCMBB
XI0_105 MBL_ MBL VSS WL_104 VSS VDD RA1SHD4096X32CCMBT
XI0_106 MBL MBL_ VSS WL_105 VSS VDD RA1SHD4096X32CCMBB
XI0_107 MBL_ MBL VSS WL_106 VSS VDD RA1SHD4096X32CCMBT
XI0_108 MBL MBL_ VSS WL_107 VSS VDD RA1SHD4096X32CCMBB
XI0_109 MBL_ MBL VSS WL_108 VSS VDD RA1SHD4096X32CCMBT
XI0_11 MBL_ MBL VSS WL_10 VSS VDD RA1SHD4096X32CCMBT
XI0_110 MBL MBL_ VSS WL_109 VSS VDD RA1SHD4096X32CCMBB
XI0_111 MBL_ MBL VSS WL_110 VSS VDD RA1SHD4096X32CCMBT
XI0_112 MBL MBL_ VSS WL_111 VSS VDD RA1SHD4096X32CCMBB
XI0_113 MBL_ MBL VSS WL_112 VSS VDD RA1SHD4096X32CCMBT
XI0_114 MBL MBL_ VSS WL_113 VSS VDD RA1SHD4096X32CCMBB
XI0_115 MBL_ MBL VSS WL_114 VSS VDD RA1SHD4096X32CCMBT
XI0_116 MBL MBL_ VSS WL_115 VSS VDD RA1SHD4096X32CCMBB
XI0_117 MBL_ MBL VSS WL_116 VSS VDD RA1SHD4096X32CCMBT
XI0_118 MBL MBL_ VSS WL_117 VSS VDD RA1SHD4096X32CCMBB
XI0_119 MBL_ MBL VSS WL_118 VSS VDD RA1SHD4096X32CCMBT
XI0_12 MBL MBL_ VSS WL_11 VSS VDD RA1SHD4096X32CCMBB
XI0_120 MBL MBL_ VSS WL_119 VSS VDD RA1SHD4096X32CCMBB
XI0_121 MBL_ MBL VSS WL_120 VSS VDD RA1SHD4096X32CCMBT
XI0_122 MBL MBL_ VSS WL_121 VSS VDD RA1SHD4096X32CCMBB
XI0_123 MBL_ MBL VSS WL_122 VSS VDD RA1SHD4096X32CCMBT
XI0_124 MBL MBL_ VSS WL_123 VSS VDD RA1SHD4096X32CCMBB
XI0_125 MBL_ MBL VSS WL_124 VSS VDD RA1SHD4096X32CCMBT
XI0_126 MBL MBL_ VSS WL_125 VSS VDD RA1SHD4096X32CCMBB
XI0_127 MBL_ MBL VSS WL_126 VSS VDD RA1SHD4096X32CCMBT
XI0_128 MBL MBL_ VSS WL_127 VSS VDD RA1SHD4096X32CCMBB
XI0_129 MBL_ MBL VSS WL_128 VSS VDD RA1SHD4096X32CCMBT
XI0_13 MBL_ MBL VSS WL_12 VSS VDD RA1SHD4096X32CCMBT
XI0_130 MBL MBL_ VSS WL_129 VSS VDD RA1SHD4096X32CCMBB
XI0_131 MBL_ MBL VSS WL_130 VSS VDD RA1SHD4096X32CCMBT
XI0_132 MBL MBL_ VSS WL_131 VSS VDD RA1SHD4096X32CCMBB
XI0_133 MBL_ MBL VSS WL_132 VSS VDD RA1SHD4096X32CCMBT
XI0_134 MBL MBL_ VSS WL_133 VSS VDD RA1SHD4096X32CCMBB
XI0_135 MBL_ MBL VSS WL_134 VSS VDD RA1SHD4096X32CCMBT
XI0_136 MBL MBL_ VSS WL_135 VSS VDD RA1SHD4096X32CCMBB
XI0_137 MBL_ MBL VSS WL_136 VSS VDD RA1SHD4096X32CCMBT
XI0_138 MBL MBL_ VSS WL_137 VSS VDD RA1SHD4096X32CCMBB
XI0_139 MBL_ MBL VSS WL_138 VSS VDD RA1SHD4096X32CCMBT
XI0_14 MBL MBL_ VSS WL_13 VSS VDD RA1SHD4096X32CCMBB
XI0_140 MBL MBL_ VSS WL_139 VSS VDD RA1SHD4096X32CCMBB
XI0_141 MBL_ MBL VSS WL_140 VSS VDD RA1SHD4096X32CCMBT
XI0_142 MBL MBL_ VSS WL_141 VSS VDD RA1SHD4096X32CCMBB
XI0_143 MBL_ MBL VSS WL_142 VSS VDD RA1SHD4096X32CCMBT
XI0_144 MBL MBL_ VSS WL_143 VSS VDD RA1SHD4096X32CCMBB
XI0_145 MBL_ MBL VSS WL_144 VSS VDD RA1SHD4096X32CCMBT
XI0_146 MBL MBL_ VSS WL_145 VSS VDD RA1SHD4096X32CCMBB
XI0_147 MBL_ MBL VSS WL_146 VSS VDD RA1SHD4096X32CCMBT
XI0_148 MBL MBL_ VSS WL_147 VSS VDD RA1SHD4096X32CCMBB
XI0_149 MBL_ MBL VSS WL_148 VSS VDD RA1SHD4096X32CCMBT
XI0_15 MBL_ MBL VSS WL_14 VSS VDD RA1SHD4096X32CCMBT
XI0_150 MBL MBL_ VSS WL_149 VSS VDD RA1SHD4096X32CCMBB
XI0_151 MBL_ MBL VSS WL_150 VSS VDD RA1SHD4096X32CCMBT
XI0_152 MBL MBL_ VSS WL_151 VSS VDD RA1SHD4096X32CCMBB
XI0_153 MBL_ MBL VSS WL_152 VSS VDD RA1SHD4096X32CCMBT
XI0_154 MBL MBL_ VSS WL_153 VSS VDD RA1SHD4096X32CCMBB
XI0_155 MBL_ MBL VSS WL_154 VSS VDD RA1SHD4096X32CCMBT
XI0_156 MBL MBL_ VSS WL_155 VSS VDD RA1SHD4096X32CCMBB
XI0_157 MBL_ MBL VSS WL_156 VSS VDD RA1SHD4096X32CCMBT
XI0_158 MBL MBL_ VSS WL_157 VSS VDD RA1SHD4096X32CCMBB
XI0_159 MBL_ MBL VSS WL_158 VSS VDD RA1SHD4096X32CCMBT
XI0_16 MBL MBL_ VSS WL_15 VSS VDD RA1SHD4096X32CCMBB
XI0_160 MBL MBL_ VSS WL_159 VSS VDD RA1SHD4096X32CCMBB
XI0_161 MBL_ MBL VSS WL_160 VSS VDD RA1SHD4096X32CCMBT
XI0_162 MBL MBL_ VSS WL_161 VSS VDD RA1SHD4096X32CCMBB
XI0_163 MBL_ MBL VSS WL_162 VSS VDD RA1SHD4096X32CCMBT
XI0_164 MBL MBL_ VSS WL_163 VSS VDD RA1SHD4096X32CCMBB
XI0_165 MBL_ MBL VSS WL_164 VSS VDD RA1SHD4096X32CCMBT
XI0_166 MBL MBL_ VSS WL_165 VSS VDD RA1SHD4096X32CCMBB
XI0_167 MBL_ MBL VSS WL_166 VSS VDD RA1SHD4096X32CCMBT
XI0_168 MBL MBL_ VSS WL_167 VSS VDD RA1SHD4096X32CCMBB
XI0_169 MBL_ MBL VSS WL_168 VSS VDD RA1SHD4096X32CCMBT
XI0_17 MBL_ MBL VSS WL_16 VSS VDD RA1SHD4096X32CCMBT
XI0_170 MBL MBL_ VSS WL_169 VSS VDD RA1SHD4096X32CCMBB
XI0_171 MBL_ MBL VSS WL_170 VSS VDD RA1SHD4096X32CCMBT
XI0_172 MBL MBL_ VSS WL_171 VSS VDD RA1SHD4096X32CCMBB
XI0_173 MBL_ MBL VSS WL_172 VSS VDD RA1SHD4096X32CCMBT
XI0_174 MBL MBL_ VSS WL_173 VSS VDD RA1SHD4096X32CCMBB
XI0_175 MBL_ MBL VSS WL_174 VSS VDD RA1SHD4096X32CCMBT
XI0_176 MBL MBL_ VSS WL_175 VSS VDD RA1SHD4096X32CCMBB
XI0_177 MBL_ MBL VSS WL_176 VSS VDD RA1SHD4096X32CCMBT
XI0_178 MBL MBL_ VSS WL_177 VSS VDD RA1SHD4096X32CCMBB
XI0_179 MBL_ MBL VSS WL_178 VSS VDD RA1SHD4096X32CCMBT
XI0_18 MBL MBL_ VSS WL_17 VSS VDD RA1SHD4096X32CCMBB
XI0_180 MBL MBL_ VSS WL_179 VSS VDD RA1SHD4096X32CCMBB
XI0_181 MBL_ MBL VSS WL_180 VSS VDD RA1SHD4096X32CCMBT
XI0_182 MBL MBL_ VSS WL_181 VSS VDD RA1SHD4096X32CCMBB
XI0_183 MBL_ MBL VSS WL_182 VSS VDD RA1SHD4096X32CCMBT
XI0_184 MBL MBL_ VSS WL_183 VSS VDD RA1SHD4096X32CCMBB
XI0_185 MBL_ MBL VSS WL_184 VSS VDD RA1SHD4096X32CCMBT
XI0_186 MBL MBL_ VSS WL_185 VSS VDD RA1SHD4096X32CCMBB
XI0_187 MBL_ MBL VSS WL_186 VSS VDD RA1SHD4096X32CCMBT
XI0_188 MBL MBL_ VSS WL_187 VSS VDD RA1SHD4096X32CCMBB
XI0_189 MBL_ MBL VSS WL_188 VSS VDD RA1SHD4096X32CCMBT
XI0_19 MBL_ MBL VSS WL_18 VSS VDD RA1SHD4096X32CCMBT
XI0_190 MBL MBL_ VSS WL_189 VSS VDD RA1SHD4096X32CCMBB
XI0_191 MBL_ MBL VSS WL_190 VSS VDD RA1SHD4096X32CCMBT
XI0_192 MBL MBL_ VSS WL_191 VSS VDD RA1SHD4096X32CCMBB
XI0_193 MBL_ MBL VSS WL_192 VSS VDD RA1SHD4096X32CCMBT
XI0_194 MBL MBL_ VSS WL_193 VSS VDD RA1SHD4096X32CCMBB
XI0_195 MBL_ MBL VSS WL_194 VSS VDD RA1SHD4096X32CCMBT
XI0_196 MBL MBL_ VSS WL_195 VSS VDD RA1SHD4096X32CCMBB
XI0_197 MBL_ MBL VSS WL_196 VSS VDD RA1SHD4096X32CCMBT
XI0_198 MBL MBL_ VSS WL_197 VSS VDD RA1SHD4096X32CCMBB
XI0_199 MBL_ MBL VSS WL_198 VSS VDD RA1SHD4096X32CCMBT
XI0_2 MBL MBL_ VSS WL_1 VSS VDD RA1SHD4096X32CCMBB
XI0_20 MBL MBL_ VSS WL_19 VSS VDD RA1SHD4096X32CCMBB
XI0_200 MBL MBL_ VSS WL_199 VSS VDD RA1SHD4096X32CCMBB
XI0_201 MBL_ MBL VSS WL_200 VSS VDD RA1SHD4096X32CCMBT
XI0_202 MBL MBL_ VSS WL_201 VSS VDD RA1SHD4096X32CCMBB
XI0_203 MBL_ MBL VSS WL_202 VSS VDD RA1SHD4096X32CCMBT
XI0_204 MBL MBL_ VSS WL_203 VSS VDD RA1SHD4096X32CCMBB
XI0_205 MBL_ MBL VSS WL_204 VSS VDD RA1SHD4096X32CCMBT
XI0_206 MBL MBL_ VSS WL_205 VSS VDD RA1SHD4096X32CCMBB
XI0_207 MBL_ MBL VSS WL_206 VSS VDD RA1SHD4096X32CCMBT
XI0_208 MBL MBL_ VSS WL_207 VSS VDD RA1SHD4096X32CCMBB
XI0_209 MBL_ MBL VSS WL_208 VSS VDD RA1SHD4096X32CCMBT
XI0_21 MBL_ MBL VSS WL_20 VSS VDD RA1SHD4096X32CCMBT
XI0_210 GTP MBL MBL_ MWLD VSS WL_209 VSS VDD RA1SHD4096X32CCPDBB
XI0_211 GTP MBL_ MBL MWLD VSS WL_210 VSS VDD RA1SHD4096X32CCPDT
XI0_212 GTP MBL MBL_ MWLD VSS WL_211 VSS VDD RA1SHD4096X32CCPDB
XI0_213 GTP MBL_ MBL MWLD VSS WL_212 VSS VDD RA1SHD4096X32CCPDT
XI0_214 GTP MBL MBL_ MWLD VSS WL_213 VSS VDD RA1SHD4096X32CCPDB
XI0_215 GTP MBL_ MBL MWLD VSS WL_214 VSS VDD RA1SHD4096X32CCPDT
XI0_216 GTP MBL MBL_ MWLD VSS WL_215 VSS VDD RA1SHD4096X32CCPDB
XI0_217 GTP MBL_ MBL MWLD VSS WL_216 VSS VDD RA1SHD4096X32CCPDT
XI0_218 GTP MBL MBL_ MWLD VSS WL_217 VSS VDD RA1SHD4096X32CCPDB
XI0_219 GTP MBL_ MBL MWLD VSS WL_218 VSS VDD RA1SHD4096X32CCPDT
XI0_22 MBL MBL_ VSS WL_21 VSS VDD RA1SHD4096X32CCMBB
XI0_220 GTP MBL MBL_ MWLD VSS WL_219 VSS VDD RA1SHD4096X32CCPDB
XI0_221 GTP MBL_ MBL MWLD VSS WL_220 VSS VDD RA1SHD4096X32CCPDT
XI0_222 GTP MBL MBL_ MWLD VSS WL_221 VSS VDD RA1SHD4096X32CCPDB
XI0_223 GTP MBL_ MBL MWLD VSS WL_222 VSS VDD RA1SHD4096X32CCPDT
XI0_224 GTP MBL MBL_ MWLD VSS WL_223 VSS VDD RA1SHD4096X32CCPDB
XI0_225 GTP MBL_ MBL MWLD VSS WL_224 VSS VDD RA1SHD4096X32CCPDT
XI0_226 GTP MBL MBL_ MWLD VSS WL_225 VSS VDD RA1SHD4096X32CCPDB
XI0_227 GTP MBL_ MBL MWLD VSS WL_226 VSS VDD RA1SHD4096X32CCPDT
XI0_228 GTP MBL MBL_ MWLD VSS WL_227 VSS VDD RA1SHD4096X32CCPDB
XI0_229 GTP MBL_ MBL MWLD VSS WL_228 VSS VDD RA1SHD4096X32CCPDT
XI0_23 MBL_ MBL VSS WL_22 VSS VDD RA1SHD4096X32CCMBT
XI0_230 GTP MBL MBL_ MWLD VSS WL_229 VSS VDD RA1SHD4096X32CCPDB
XI0_231 GTP MBL_ MBL MWLD VSS WL_230 VSS VDD RA1SHD4096X32CCPDT
XI0_232 GTP MBL MBL_ MWLD VSS WL_231 VSS VDD RA1SHD4096X32CCPDB
XI0_233 GTP MBL_ MBL MWLD VSS WL_232 VSS VDD RA1SHD4096X32CCPDT
XI0_234 GTP MBL MBL_ MWLD VSS WL_233 VSS VDD RA1SHD4096X32CCPDB
XI0_235 GTP MBL_ MBL MWLD VSS WL_234 VSS VDD RA1SHD4096X32CCPDT
XI0_236 GTP MBL MBL_ MWLD VSS WL_235 VSS VDD RA1SHD4096X32CCPDB
XI0_237 GTP MBL_ MBL MWLD VSS WL_236 VSS VDD RA1SHD4096X32CCPDT
XI0_238 GTP MBL MBL_ MWLD VSS WL_237 VSS VDD RA1SHD4096X32CCPDB
XI0_239 GTP MBL_ MBL MWLD VSS WL_238 VSS VDD RA1SHD4096X32CCPDT
XI0_24 MBL MBL_ VSS WL_23 VSS VDD RA1SHD4096X32CCMBB
XI0_240 GTP MBL MBL_ MWLD VSS WL_239 VSS VDD RA1SHD4096X32CCPDB
XI0_241 GTP MBL_ MBL MWLD VSS WL_240 VSS VDD RA1SHD4096X32CCPDT
XI0_242 GTP MBL MBL_ MWLD VSS WL_241 VSS VDD RA1SHD4096X32CCPDB
XI0_243 GTP MBL_ MBL MWLD VSS WL_242 VSS VDD RA1SHD4096X32CCPDT
XI0_244 GTP MBL MBL_ MWLD VSS WL_243 VSS VDD RA1SHD4096X32CCPDB
XI0_245 GTP MBL_ MBL MWLD VSS WL_244 VSS VDD RA1SHD4096X32CCPDT
XI0_246 GTP MBL MBL_ MWLD VSS WL_245 VSS VDD RA1SHD4096X32CCPDB
XI0_247 GTP MBL_ MBL MWLD VSS WL_246 VSS VDD RA1SHD4096X32CCPDT
XI0_248 GTP MBL MBL_ MWLD VSS WL_247 VSS VDD RA1SHD4096X32CCPDB
XI0_249 GTP MBL_ MBL MWLD VSS WL_248 VSS VDD RA1SHD4096X32CCPDT
XI0_25 MBL_ MBL VSS WL_24 VSS VDD RA1SHD4096X32CCMBT
XI0_250 GTP MBL MBL_ MWLD VSS WL_249 VSS VDD RA1SHD4096X32CCPDB
XI0_251 GTP MBL_ MBL MWLD VSS WL_250 VSS VDD RA1SHD4096X32CCPDT
XI0_252 GTP MBL MBL_ MWLD VSS WL_251 VSS VDD RA1SHD4096X32CCPDB
XI0_253 GTP MBL_ MBL MWLD VSS WL_252 VSS VDD RA1SHD4096X32CCPDT
XI0_254 GTP MBL MBL_ MWLD VSS WL_253 VSS VDD RA1SHD4096X32CCPDB
XI0_255 GTP MBL_ MBL MWLD VSS WL_254 VSS VDD RA1SHD4096X32CCPDT
XI0_256 GTP MBL MBL_ MWLD MWLS VSS VDD RA1SHD4096X32MBLBASE
XI0_26 MBL MBL_ VSS WL_25 VSS VDD RA1SHD4096X32CCMBB
XI0_27 MBL_ MBL VSS WL_26 VSS VDD RA1SHD4096X32CCMBT
XI0_28 MBL MBL_ VSS WL_27 VSS VDD RA1SHD4096X32CCMBB
XI0_29 MBL_ MBL VSS WL_28 VSS VDD RA1SHD4096X32CCMBT
XI0_3 MBL_ MBL VSS WL_2 VSS VDD RA1SHD4096X32CCMBT
XI0_30 MBL MBL_ VSS WL_29 VSS VDD RA1SHD4096X32CCMBB
XI0_31 MBL_ MBL VSS WL_30 VSS VDD RA1SHD4096X32CCMBT
XI0_32 MBL MBL_ VSS WL_31 VSS VDD RA1SHD4096X32CCMBB
XI0_33 MBL_ MBL VSS WL_32 VSS VDD RA1SHD4096X32CCMBT
XI0_34 MBL MBL_ VSS WL_33 VSS VDD RA1SHD4096X32CCMBB
XI0_35 MBL_ MBL VSS WL_34 VSS VDD RA1SHD4096X32CCMBT
XI0_36 MBL MBL_ VSS WL_35 VSS VDD RA1SHD4096X32CCMBB
XI0_37 MBL_ MBL VSS WL_36 VSS VDD RA1SHD4096X32CCMBT
XI0_38 MBL MBL_ VSS WL_37 VSS VDD RA1SHD4096X32CCMBB
XI0_39 MBL_ MBL VSS WL_38 VSS VDD RA1SHD4096X32CCMBT
XI0_4 MBL MBL_ VSS WL_3 VSS VDD RA1SHD4096X32CCMBB
XI0_40 MBL MBL_ VSS WL_39 VSS VDD RA1SHD4096X32CCMBB
XI0_41 MBL_ MBL VSS WL_40 VSS VDD RA1SHD4096X32CCMBT
XI0_42 MBL MBL_ VSS WL_41 VSS VDD RA1SHD4096X32CCMBB
XI0_43 MBL_ MBL VSS WL_42 VSS VDD RA1SHD4096X32CCMBT
XI0_44 MBL MBL_ VSS WL_43 VSS VDD RA1SHD4096X32CCMBB
XI0_45 MBL_ MBL VSS WL_44 VSS VDD RA1SHD4096X32CCMBT
XI0_46 MBL MBL_ VSS WL_45 VSS VDD RA1SHD4096X32CCMBB
XI0_47 MBL_ MBL VSS WL_46 VSS VDD RA1SHD4096X32CCMBT
XI0_48 MBL MBL_ VSS WL_47 VSS VDD RA1SHD4096X32CCMBB
XI0_49 MBL_ MBL VSS WL_48 VSS VDD RA1SHD4096X32CCMBT
XI0_5 MBL_ MBL VSS WL_4 VSS VDD RA1SHD4096X32CCMBT
XI0_50 MBL MBL_ VSS WL_49 VSS VDD RA1SHD4096X32CCMBB
XI0_51 MBL_ MBL VSS WL_50 VSS VDD RA1SHD4096X32CCMBT
XI0_52 MBL MBL_ VSS WL_51 VSS VDD RA1SHD4096X32CCMBB
XI0_53 MBL_ MBL VSS WL_52 VSS VDD RA1SHD4096X32CCMBT
XI0_54 MBL MBL_ VSS WL_53 VSS VDD RA1SHD4096X32CCMBB
XI0_55 MBL_ MBL VSS WL_54 VSS VDD RA1SHD4096X32CCMBT
XI0_56 MBL MBL_ VSS WL_55 VSS VDD RA1SHD4096X32CCMBB
XI0_57 MBL_ MBL VSS WL_56 VSS VDD RA1SHD4096X32CCMBT
XI0_58 MBL MBL_ VSS WL_57 VSS VDD RA1SHD4096X32CCMBB
XI0_59 MBL_ MBL VSS WL_58 VSS VDD RA1SHD4096X32CCMBT
XI0_6 MBL MBL_ VSS WL_5 VSS VDD RA1SHD4096X32CCMBB
XI0_60 MBL MBL_ VSS WL_59 VSS VDD RA1SHD4096X32CCMBB
XI0_61 MBL_ MBL VSS WL_60 VSS VDD RA1SHD4096X32CCMBT
XI0_62 MBL MBL_ VSS WL_61 VSS VDD RA1SHD4096X32CCMBB
XI0_63 MBL_ MBL VSS WL_62 VSS VDD RA1SHD4096X32CCMBT
XI0_64 MBL MBL_ VSS WL_63 VSS VDD RA1SHD4096X32CCMBB
XI0_65 MBL_ MBL VSS WL_64 VSS VDD RA1SHD4096X32CCMBT
XI0_66 MBL MBL_ VSS WL_65 VSS VDD RA1SHD4096X32CCMBB
XI0_67 MBL_ MBL VSS WL_66 VSS VDD RA1SHD4096X32CCMBT
XI0_68 MBL MBL_ VSS WL_67 VSS VDD RA1SHD4096X32CCMBB
XI0_69 MBL_ MBL VSS WL_68 VSS VDD RA1SHD4096X32CCMBT
XI0_7 MBL_ MBL VSS WL_6 VSS VDD RA1SHD4096X32CCMBT
XI0_70 MBL MBL_ VSS WL_69 VSS VDD RA1SHD4096X32CCMBB
XI0_71 MBL_ MBL VSS WL_70 VSS VDD RA1SHD4096X32CCMBT
XI0_72 MBL MBL_ VSS WL_71 VSS VDD RA1SHD4096X32CCMBB
XI0_73 MBL_ MBL VSS WL_72 VSS VDD RA1SHD4096X32CCMBT
XI0_74 MBL MBL_ VSS WL_73 VSS VDD RA1SHD4096X32CCMBB
XI0_75 MBL_ MBL VSS WL_74 VSS VDD RA1SHD4096X32CCMBT
XI0_76 MBL MBL_ VSS WL_75 VSS VDD RA1SHD4096X32CCMBB
XI0_77 MBL_ MBL VSS WL_76 VSS VDD RA1SHD4096X32CCMBT
XI0_78 MBL MBL_ VSS WL_77 VSS VDD RA1SHD4096X32CCMBB
XI0_79 MBL_ MBL VSS WL_78 VSS VDD RA1SHD4096X32CCMBT
XI0_8 MBL MBL_ VSS WL_7 VSS VDD RA1SHD4096X32CCMBB
XI0_80 MBL MBL_ VSS WL_79 VSS VDD RA1SHD4096X32CCMBB
XI0_81 MBL_ MBL VSS WL_80 VSS VDD RA1SHD4096X32CCMBT
XI0_82 MBL MBL_ VSS WL_81 VSS VDD RA1SHD4096X32CCMBB
XI0_83 MBL_ MBL VSS WL_82 VSS VDD RA1SHD4096X32CCMBT
XI0_84 MBL MBL_ VSS WL_83 VSS VDD RA1SHD4096X32CCMBB
XI0_85 MBL_ MBL VSS WL_84 VSS VDD RA1SHD4096X32CCMBT
XI0_86 MBL MBL_ VSS WL_85 VSS VDD RA1SHD4096X32CCMBB
XI0_87 MBL_ MBL VSS WL_86 VSS VDD RA1SHD4096X32CCMBT
XI0_88 MBL MBL_ VSS WL_87 VSS VDD RA1SHD4096X32CCMBB
XI0_89 MBL_ MBL VSS WL_88 VSS VDD RA1SHD4096X32CCMBT
XI0_9 MBL_ MBL VSS WL_8 VSS VDD RA1SHD4096X32CCMBT
XI0_90 MBL MBL_ VSS WL_89 VSS VDD RA1SHD4096X32CCMBB
XI0_91 MBL_ MBL VSS WL_90 VSS VDD RA1SHD4096X32CCMBT
XI0_92 MBL MBL_ VSS WL_91 VSS VDD RA1SHD4096X32CCMBB
XI0_93 MBL_ MBL VSS WL_92 VSS VDD RA1SHD4096X32CCMBT
XI0_94 MBL MBL_ VSS WL_93 VSS VDD RA1SHD4096X32CCMBB
XI0_95 MBL_ MBL VSS WL_94 VSS VDD RA1SHD4096X32CCMBT
XI0_96 MBL MBL_ VSS WL_95 VSS VDD RA1SHD4096X32CCMBB
XI0_97 MBL_ MBL VSS WL_96 VSS VDD RA1SHD4096X32CCMBT
XI0_98 MBL MBL_ VSS WL_97 VSS VDD RA1SHD4096X32CCMBB
XI0_99 MBL_ MBL VSS WL_98 VSS VDD RA1SHD4096X32CCMBT
.ENDS RA1SHD4096X32MODEL_COL
****
.SUBCKT RA1SHD4096X32 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] A[10]
+  A[11] CEN CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11]
+  D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23]
+  D[24] D[25] D[26] D[27] D[28] D[29] D[30] D[31] OEN Q[0] Q[1] Q[2] Q[3]
+  Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16]
+  Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] Q[28]
+  Q[29] Q[30] Q[31] WEN[0] WEN[1] WEN[2] WEN[3] VSS VDD
** RA1SHD4096X32: 819460 flat devices **
XI0_0 A0 A0_ DR DR_ DW DW_ GTP_1 GTP_1 GTP_1 OE_ VSS WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76
+  WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88
+  WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100
+  WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110
+  WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120
+  WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130
+  WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140
+  WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150
+  WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160
+  WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170
+  WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180
+  WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190
+  WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200
+  WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210
+  WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220
+  WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230
+  WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240
+  WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250
+  WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VSS VDD RA1SHD4096X32LEFT_CAP
XI1_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22
+  BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34
+  BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46
+  BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58
+  BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70
+  BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82
+  BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94
+  BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105
+  BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115
+  BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125
+  BL_126 BL_127 BL_128 BL_129 BL_130 BL_131 BL_132 BL_133 BL_134 BL_135
+  BL_136 BL_137 BL_138 BL_139 BL_140 BL_141 BL_142 BL_143 BL_144 BL_145
+  BL_146 BL_147 BL_148 BL_149 BL_150 BL_151 BL_152 BL_153 BL_154 BL_155
+  BL_156 BL_157 BL_158 BL_159 BL_160 BL_161 BL_162 BL_163 BL_164 BL_165
+  BL_166 BL_167 BL_168 BL_169 BL_170 BL_171 BL_172 BL_173 BL_174 BL_175
+  BL_176 BL_177 BL_178 BL_179 BL_180 BL_181 BL_182 BL_183 BL_184 BL_185
+  BL_186 BL_187 BL_188 BL_189 BL_190 BL_191 BL_192 BL_193 BL_194 BL_195
+  BL_196 BL_197 BL_198 BL_199 BL_200 BL_201 BL_202 BL_203 BL_204 BL_205
+  BL_206 BL_207 BL_208 BL_209 BL_210 BL_211 BL_212 BL_213 BL_214 BL_215
+  BL_216 BL_217 BL_218 BL_219 BL_220 BL_221 BL_222 BL_223 BL_224 BL_225
+  BL_226 BL_227 BL_228 BL_229 BL_230 BL_231 BL_232 BL_233 BL_234 BL_235
+  BL_236 BL_237 BL_238 BL_239 BL_240 BL_241 BL_242 BL_243 BL_244 BL_245
+  BL_246 BL_247 BL_248 BL_249 BL_250 BL_251 BL_252 BL_253 BL_254 BL__0 BL__1
+  BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13
+  BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23
+  BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33
+  BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43
+  BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53
+  BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63
+  BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73
+  BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83
+  BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93
+  BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103
+  BL__104 BL__105 BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112
+  BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121
+  BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 BL__128 BL__129 BL__130
+  BL__131 BL__132 BL__133 BL__134 BL__135 BL__136 BL__137 BL__138 BL__139
+  BL__140 BL__141 BL__142 BL__143 BL__144 BL__145 BL__146 BL__147 BL__148
+  BL__149 BL__150 BL__151 BL__152 BL__153 BL__154 BL__155 BL__156 BL__157
+  BL__158 BL__159 BL__160 BL__161 BL__162 BL__163 BL__164 BL__165 BL__166
+  BL__167 BL__168 BL__169 BL__170 BL__171 BL__172 BL__173 BL__174 BL__175
+  BL__176 BL__177 BL__178 BL__179 BL__180 BL__181 BL__182 BL__183 BL__184
+  BL__185 BL__186 BL__187 BL__188 BL__189 BL__190 BL__191 BL__192 BL__193
+  BL__194 BL__195 BL__196 BL__197 BL__198 BL__199 BL__200 BL__201 BL__202
+  BL__203 BL__204 BL__205 BL__206 BL__207 BL__208 BL__209 BL__210 BL__211
+  BL__212 BL__213 BL__214 BL__215 BL__216 BL__217 BL__218 BL__219 BL__220
+  BL__221 BL__222 BL__223 BL__224 BL__225 BL__226 BL__227 BL__228 BL__229
+  BL__230 BL__231 BL__232 BL__233 BL__234 BL__235 BL__236 BL__237 BL__238
+  BL__239 BL__240 BL__241 BL__242 BL__243 BL__244 BL__245 BL__246 BL__247
+  BL__248 BL__249 BL__250 BL__251 BL__252 BL__253 BL__254 WEN[1] WEN[0] D[15]
+  D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5] D[4] D[3] D[2] D[1]
+  D[0] GTP_1 GTP_1 GTP_1 OE_ Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9] Q[8]
+  Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] DR DR_ VSS VSS DW DW_ VSS VSS WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73
+  WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85
+  WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97
+  WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108
+  WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118
+  WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128
+  WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138
+  WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148
+  WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158
+  WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168
+  WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178
+  WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188
+  WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198
+  WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208
+  WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218
+  WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228
+  WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238
+  WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248
+  WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32WING_16_LEFT
XI1_5 BL_ BL__127 BL_127 BL__128 BL_128 BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL_15 BL_16
+  BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28
+  BL_29 BL_30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39
+  BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL_47 BL_48 BL_49 BL_50
+  BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62
+  BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BL__71 BL__72
+  BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL_79 BL_80 BL_81 BL_82 BL_83
+  BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL__95
+  BL__96 BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL_111 BL_112 BL_113 BL_114 BL_115
+  BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125
+  BL_126 BL__129 BL__130 BL__131 BL__132 BL__133 BL__134 BL__135 BL__136
+  BL__137 BL__138 BL__139 BL__140 BL__141 BL__142 BL_143 BL_144 BL_145 BL_146
+  BL_147 BL_148 BL_149 BL_150 BL_151 BL_152 BL_153 BL_154 BL_155 BL_156
+  BL_157 BL_158 BL__159 BL__160 BL__161 BL__162 BL__163 BL__164 BL__165
+  BL__166 BL__167 BL__168 BL__169 BL__170 BL__171 BL__172 BL__173 BL__174
+  BL_175 BL_176 BL_177 BL_178 BL_179 BL_180 BL_181 BL_182 BL_183 BL_184
+  BL_185 BL_186 BL_187 BL_188 BL_189 BL_190 BL__191 BL__192 BL__193 BL__194
+  BL__195 BL__196 BL__197 BL__198 BL__199 BL__200 BL__201 BL__202 BL__203
+  BL__204 BL__205 BL__206 BL_207 BL_208 BL_209 BL_210 BL_211 BL_212 BL_213
+  BL_214 BL_215 BL_216 BL_217 BL_218 BL_219 BL_220 BL_221 BL_222 BL__223
+  BL__224 BL__225 BL__226 BL__227 BL__228 BL__229 BL__230 BL__231 BL__232
+  BL__233 BL__234 BL__235 BL__236 BL__237 BL__238 BL_239 BL_240 BL_241 BL_242
+  BL_243 BL_244 BL_245 BL_246 BL_247 BL_248 BL_249 BL_250 BL_251 BL_252
+  BL_253 BL_254 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22
+  BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL_31 BL_32 BL_33
+  BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45
+  BL_46 BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL_63 BL_64 BL_65 BL_66 BL_67
+  BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL__79
+  BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89
+  BL__90 BL__91 BL__92 BL__93 BL__94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100
+  BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110
+  BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 BL__119
+  BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL_129 BL_130
+  BL_131 BL_132 BL_133 BL_134 BL_135 BL_136 BL_137 BL_138 BL_139 BL_140
+  BL_141 BL_142 BL__143 BL__144 BL__145 BL__146 BL__147 BL__148 BL__149
+  BL__150 BL__151 BL__152 BL__153 BL__154 BL__155 BL__156 BL__157 BL__158
+  BL_159 BL_160 BL_161 BL_162 BL_163 BL_164 BL_165 BL_166 BL_167 BL_168
+  BL_169 BL_170 BL_171 BL_172 BL_173 BL_174 BL__175 BL__176 BL__177 BL__178
+  BL__179 BL__180 BL__181 BL__182 BL__183 BL__184 BL__185 BL__186 BL__187
+  BL__188 BL__189 BL__190 BL_191 BL_192 BL_193 BL_194 BL_195 BL_196 BL_197
+  BL_198 BL_199 BL_200 BL_201 BL_202 BL_203 BL_204 BL_205 BL_206 BL__207
+  BL__208 BL__209 BL__210 BL__211 BL__212 BL__213 BL__214 BL__215 BL__216
+  BL__217 BL__218 BL__219 BL__220 BL__221 BL__222 BL_223 BL_224 BL_225 BL_226
+  BL_227 BL_228 BL_229 BL_230 BL_231 BL_232 BL_233 BL_234 BL_235 BL_236
+  BL_237 BL_238 BL__239 BL__240 BL__241 BL__242 BL__243 BL__244 BL__245
+  BL__246 BL__247 BL__248 BL__249 BL__250 BL__251 BL__252 BL__253 BL__254
+  MWLB VSS VSS VDD RA1SHD4096X32MODEL_ROW_16
XI3_0 A[10] A[7] A[4] A[11] A[8] A[5] A[9] A[6] AGTPT AGTPT A0 A0_ VSS OE_ VSS
+  XP_0 XP_0_0 XP_0_1 XP_1 XP_1_0 XP_1_1 XP_2 XP_2_0 XP_2_1 XP_3 XP_3_0 XP_3_1
+  XP_4 XP_4_0 XP_5 XP_5_0 XP_6 XP_6_0 XP_7 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32X_PRE_DECODE
XI3_3 GTP_1 MBL MBL_ MWLB WL WL_2 WL_3 WL_6 WL_7 WL_10 WL_11 WL_14 WL_15 WL_18
+  WL_19 WL_22 WL_23 WL_26 WL_27 WL_30 WL_31 WL_34 WL_35 WL_38 WL_39 WL_42
+  WL_43 WL_46 WL_47 WL_50 WL_51 WL_54 WL_55 WL_58 WL_59 WL_62 WL_63 WL_66
+  WL_67 WL_70 WL_71 WL_74 WL_75 WL_78 WL_79 WL_82 WL_83 WL_86 WL_87 WL_90
+  WL_91 WL_94 WL_95 WL_98 WL_99 WL_102 WL_103 WL_106 WL_107 WL_110 WL_111
+  WL_114 WL_115 WL_118 WL_119 WL_122 WL_123 WL_126 WL_127 WL_130 WL_131
+  WL_134 WL_135 WL_138 WL_139 WL_142 WL_143 WL_146 WL_147 WL_150 WL_151
+  WL_154 WL_155 WL_158 WL_159 WL_162 WL_163 WL_166 WL_167 WL_170 WL_171
+  WL_174 WL_175 WL_178 WL_179 WL_182 WL_183 WL_186 WL_187 WL_190 WL_191
+  WL_194 WL_195 WL_198 WL_199 WL_202 WL_203 WL_206 WL_207 WL_210 WL_211
+  WL_214 WL_215 WL_218 WL_219 WL_222 WL_223 WL_226 WL_227 WL_230 WL_231
+  WL_234 WL_235 WL_238 WL_239 WL_242 WL_243 WL_246 WL_247 WL_250 WL_251
+  WL_254 WL_0 WL_1 WL_4 WL_5 WL_8 WL_9 WL_12 WL_13 WL_16 WL_17 WL_20 WL_21
+  WL_24 WL_25 WL_28 WL_29 WL_32 WL_33 WL_36 WL_37 WL_40 WL_41 WL_44 WL_45
+  WL_48 WL_49 WL_52 WL_53 WL_56 WL_57 WL_60 WL_61 WL_64 WL_65 WL_68 WL_69
+  WL_72 WL_73 WL_76 WL_77 WL_80 WL_81 WL_84 WL_85 WL_88 WL_89 WL_92 WL_93
+  WL_96 WL_97 WL_100 WL_101 WL_104 WL_105 WL_108 WL_109 WL_112 WL_113 WL_116
+  WL_117 WL_120 WL_121 WL_124 WL_125 WL_128 WL_129 WL_132 WL_133 WL_136
+  WL_137 WL_140 WL_141 WL_144 WL_145 WL_148 WL_149 WL_152 WL_153 WL_156
+  WL_157 WL_160 WL_161 WL_164 WL_165 WL_168 WL_169 WL_172 WL_173 WL_176
+  WL_177 WL_180 WL_181 WL_184 WL_185 WL_188 WL_189 WL_192 WL_193 WL_196
+  WL_197 WL_200 WL_201 WL_204 WL_205 WL_208 WL_209 WL_212 WL_213 WL_216
+  WL_217 WL_220 WL_221 WL_224 WL_225 WL_228 WL_229 WL_232 WL_233 WL_236
+  WL_237 WL_240 WL_241 WL_244 WL_245 WL_248 WL_249 WL_252 WL_253 XP_2 XP_0
+  XP_6 XP_4 XP_2_0 XP_0_0 XP_3 XP_1 XP_7 XP_5 XP_3_0 XP_1_0 XP_0_1 XP_1_1
+  XP_2_1 XP_3_1 XP_4_0 XP_5_0 XP_6_0 XP_7_0 VSS VDD RA1SHD4096X32WORD_ROWS
XI4_0 A[1] A[0] A[2] A[3] AGTPT A0 A0_ VSS CLK GSRCN GTPN OE_ RST VSS YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32Y_DECODE
XI5_0 CEN CEN_ CLK GSRCN GTP_1 GTPN MBL OE_ OEN OEN_ RST VSS WE VSS WEN_ VSS
+  VDD RA1SHD4096X32HBFX
XI5_2 A0 A0_ AGTPT CLK GSRCN GTP_1 GTPN GTP_1 GTP_1 GTP_1 RST YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32CLK_DRVS
XI6_2 A0 A0_ CLK GSRCN GTP_1 GTPN MBL MBL_ RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD4096X32FLCIO
XI6_4 GTP_1 MBL MBL_ MWLB MWLB WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 VSS VDD RA1SHD4096X32MODEL_COL
XI7_0 A0 A0_ BL_1835 BL__1837 BL_0_1831 BL_1_1827 BL_2_1823 BL_3_1819
+  BL_4_1815 BL_5_1811 BL_6_1807 BL_7_1803 BL_8_1799 BL_9_1795 BL_10_1791
+  BL_11_1787 BL_12_1783 BL_13_1779 BL_14_1775 BL_15_1773 BL_16_1769
+  BL_17_1765 BL_18_1761 BL_19_1757 BL_20_1753 BL_21_1749 BL_22_1745
+  BL_23_1741 BL_24_1737 BL_25_1733 BL_26_1729 BL_27_1725 BL_28_1721
+  BL_29_1717 BL_30_1713 BL_31_1707 BL_32_1703 BL_33_1699 BL_34_1695
+  BL_35_1691 BL_36_1687 BL_37_1683 BL_38_1679 BL_39_1675 BL_40_1671
+  BL_41_1667 BL_42_1663 BL_43_1659 BL_44_1655 BL_45_1651 BL_46_1647
+  BL_47_1645 BL_48_1641 BL_49_1637 BL_50_1633 BL_51_1629 BL_52_1625
+  BL_53_1621 BL_54_1617 BL_55_1613 BL_56_1609 BL_57_1605 BL_58_1601
+  BL_59_1597 BL_60_1593 BL_61_1589 BL_62_1585 BL_63_1579 BL_64_1575
+  BL_65_1571 BL_66_1567 BL_67_1563 BL_68_1559 BL_69_1555 BL_70_1551
+  BL_71_1547 BL_72_1543 BL_73_1539 BL_74_1535 BL_75_1531 BL_76_1527
+  BL_77_1523 BL_78_1519 BL_79_1517 BL_80_1513 BL_81_1509 BL_82_1505
+  BL_83_1501 BL_84_1497 BL_85_1493 BL_86_1489 BL_87_1485 BL_88_1481
+  BL_89_1477 BL_90_1473 BL_91_1469 BL_92_1465 BL_93_1461 BL_94_1457
+  BL_95_1451 BL_96_1447 BL_97_1443 BL_98_1439 BL_99_1435 BL_100_1431
+  BL_101_1427 BL_102_1423 BL_103_1419 BL_104_1415 BL_105_1411 BL_106_1407
+  BL_107_1403 BL_108_1399 BL_109_1395 BL_110_1391 BL_111_1389 BL_112_1385
+  BL_113_1381 BL_114_1377 BL_115_1373 BL_116_1369 BL_117_1365 BL_118_1361
+  BL_119_1357 BL_120_1353 BL_121_1349 BL_122_1345 BL_123_1341 BL_124_1337
+  BL_125_1333 BL_126_1329 BL_127_1323 BL_128_1319 BL_129_1315 BL_130_1311
+  BL_131_1307 BL_132_1303 BL_133_1299 BL_134_1295 BL_135_1291 BL_136_1287
+  BL_137_1283 BL_138_1279 BL_139_1275 BL_140_1271 BL_141_1267 BL_142_1263
+  BL_143_1261 BL_144_1257 BL_145_1253 BL_146_1249 BL_147_1245 BL_148_1241
+  BL_149_1237 BL_150_1233 BL_151_1229 BL_152_1225 BL_153_1221 BL_154_1217
+  BL_155_1213 BL_156_1209 BL_157_1205 BL_158_1201 BL_159_1195 BL_160_1191
+  BL_161_1187 BL_162_1183 BL_163_1179 BL_164_1175 BL_165_1171 BL_166_1167
+  BL_167_1163 BL_168_1159 BL_169_1155 BL_170_1151 BL_171_1147 BL_172_1143
+  BL_173_1139 BL_174_1135 BL_175_1133 BL_176_1129 BL_177_1125 BL_178_1121
+  BL_179_1117 BL_180_1113 BL_181_1109 BL_182_1105 BL_183_1101 BL_184_1097
+  BL_185_1093 BL_186_1089 BL_187_1085 BL_188_1081 BL_189_1077 BL_190_1073
+  BL_191_1067 BL_192_1063 BL_193_1059 BL_194_1055 BL_195_1051 BL_196_1047
+  BL_197_1043 BL_198_1039 BL_199_1035 BL_200_1031 BL_201_1027 BL_202_1023
+  BL_203_1019 BL_204_1015 BL_205_1011 BL_206_1007 BL_207_1005 BL_208_1001
+  BL_209_997 BL_210_993 BL_211_989 BL_212_985 BL_213_981 BL_214_977
+  BL_215_973 BL_216_969 BL_217_965 BL_218_961 BL_219_957 BL_220_953
+  BL_221_949 BL_222_945 BL_223_939 BL_224_935 BL_225_931 BL_226_927
+  BL_227_923 BL_228_919 BL_229_915 BL_230_911 BL_231_907 BL_232_903
+  BL_233_899 BL_234_895 BL_235_891 BL_236_887 BL_237_883 BL_238_879
+  BL_239_877 BL_240_873 BL_241_869 BL_242_865 BL_243_861 BL_244_857
+  BL_245_853 BL_246_849 BL_247_845 BL_248_841 BL_249_837 BL_250_833
+  BL_251_829 BL_252_825 BL_253_821 BL_254_817 BL__0_1833 BL__1_1829
+  BL__2_1825 BL__3_1821 BL__4_1817 BL__5_1813 BL__6_1809 BL__7_1805
+  BL__8_1801 BL__9_1797 BL__10_1793 BL__11_1789 BL__12_1785 BL__13_1781
+  BL__14_1777 BL__15_1771 BL__16_1767 BL__17_1763 BL__18_1759 BL__19_1755
+  BL__20_1751 BL__21_1747 BL__22_1743 BL__23_1739 BL__24_1735 BL__25_1731
+  BL__26_1727 BL__27_1723 BL__28_1719 BL__29_1715 BL__30_1711 BL__31_1709
+  BL__32_1705 BL__33_1701 BL__34_1697 BL__35_1693 BL__36_1689 BL__37_1685
+  BL__38_1681 BL__39_1677 BL__40_1673 BL__41_1669 BL__42_1665 BL__43_1661
+  BL__44_1657 BL__45_1653 BL__46_1649 BL__47_1643 BL__48_1639 BL__49_1635
+  BL__50_1631 BL__51_1627 BL__52_1623 BL__53_1619 BL__54_1615 BL__55_1611
+  BL__56_1607 BL__57_1603 BL__58_1599 BL__59_1595 BL__60_1591 BL__61_1587
+  BL__62_1583 BL__63_1581 BL__64_1577 BL__65_1573 BL__66_1569 BL__67_1565
+  BL__68_1561 BL__69_1557 BL__70_1553 BL__71_1549 BL__72_1545 BL__73_1541
+  BL__74_1537 BL__75_1533 BL__76_1529 BL__77_1525 BL__78_1521 BL__79_1515
+  BL__80_1511 BL__81_1507 BL__82_1503 BL__83_1499 BL__84_1495 BL__85_1491
+  BL__86_1487 BL__87_1483 BL__88_1479 BL__89_1475 BL__90_1471 BL__91_1467
+  BL__92_1463 BL__93_1459 BL__94_1455 BL__95_1453 BL__96_1449 BL__97_1445
+  BL__98_1441 BL__99_1437 BL__100_1433 BL__101_1429 BL__102_1425 BL__103_1421
+  BL__104_1417 BL__105_1413 BL__106_1409 BL__107_1405 BL__108_1401
+  BL__109_1397 BL__110_1393 BL__111_1387 BL__112_1383 BL__113_1379
+  BL__114_1375 BL__115_1371 BL__116_1367 BL__117_1363 BL__118_1359
+  BL__119_1355 BL__120_1351 BL__121_1347 BL__122_1343 BL__123_1339
+  BL__124_1335 BL__125_1331 BL__126_1327 BL__127_1325 BL__128_1321
+  BL__129_1317 BL__130_1313 BL__131_1309 BL__132_1305 BL__133_1301
+  BL__134_1297 BL__135_1293 BL__136_1289 BL__137_1285 BL__138_1281
+  BL__139_1277 BL__140_1273 BL__141_1269 BL__142_1265 BL__143_1259
+  BL__144_1255 BL__145_1251 BL__146_1247 BL__147_1243 BL__148_1239
+  BL__149_1235 BL__150_1231 BL__151_1227 BL__152_1223 BL__153_1219
+  BL__154_1215 BL__155_1211 BL__156_1207 BL__157_1203 BL__158_1199
+  BL__159_1197 BL__160_1193 BL__161_1189 BL__162_1185 BL__163_1181
+  BL__164_1177 BL__165_1173 BL__166_1169 BL__167_1165 BL__168_1161
+  BL__169_1157 BL__170_1153 BL__171_1149 BL__172_1145 BL__173_1141
+  BL__174_1137 BL__175_1131 BL__176_1127 BL__177_1123 BL__178_1119
+  BL__179_1115 BL__180_1111 BL__181_1107 BL__182_1103 BL__183_1099
+  BL__184_1095 BL__185_1091 BL__186_1087 BL__187_1083 BL__188_1079
+  BL__189_1075 BL__190_1071 BL__191_1069 BL__192_1065 BL__193_1061
+  BL__194_1057 BL__195_1053 BL__196_1049 BL__197_1045 BL__198_1041
+  BL__199_1037 BL__200_1033 BL__201_1029 BL__202_1025 BL__203_1021
+  BL__204_1017 BL__205_1013 BL__206_1009 BL__207_1003 BL__208_999 BL__209_995
+  BL__210_991 BL__211_987 BL__212_983 BL__213_979 BL__214_975 BL__215_971
+  BL__216_967 BL__217_963 BL__218_959 BL__219_955 BL__220_951 BL__221_947
+  BL__222_943 BL__223_941 BL__224_937 BL__225_933 BL__226_929 BL__227_925
+  BL__228_921 BL__229_917 BL__230_913 BL__231_909 BL__232_905 BL__233_901
+  BL__234_897 BL__235_893 BL__236_889 BL__237_885 BL__238_881 BL__239_875
+  BL__240_871 BL__241_867 BL__242_863 BL__243_859 BL__244_855 BL__245_851
+  BL__246_847 BL__247_843 BL__248_839 BL__249_835 BL__250_831 BL__251_827
+  BL__252_823 BL__253_819 BL__254_815 WEN[2] WEN[3] D[16] D[17] D[18] D[19]
+  D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29] D[30] D[31]
+  GTP_1 GTP_1 GTP_1 OE_ Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24]
+  Q[25] Q[26] Q[27] Q[28] Q[29] Q[30] Q[31] VSS VSS STUBDR_0 STUBDR__0 VSS
+  VSS STUBDW_0 STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32WING_16_RIGHT
XI7_5 BL__1837 BL__127_1325 BL_127_1323 BL__128_1321 BL_128_1319 BL_1835
+  BL__0_1833 BL__1_1829 BL__2_1825 BL__3_1821 BL__4_1817 BL__5_1813
+  BL__6_1809 BL__7_1805 BL__8_1801 BL__9_1797 BL__10_1793 BL__11_1789
+  BL__12_1785 BL__13_1781 BL__14_1777 BL_15_1773 BL_16_1769 BL_17_1765
+  BL_18_1761 BL_19_1757 BL_20_1753 BL_21_1749 BL_22_1745 BL_23_1741
+  BL_24_1737 BL_25_1733 BL_26_1729 BL_27_1725 BL_28_1721 BL_29_1717
+  BL_30_1713 BL__31_1709 BL__32_1705 BL__33_1701 BL__34_1697 BL__35_1693
+  BL__36_1689 BL__37_1685 BL__38_1681 BL__39_1677 BL__40_1673 BL__41_1669
+  BL__42_1665 BL__43_1661 BL__44_1657 BL__45_1653 BL__46_1649 BL_47_1645
+  BL_48_1641 BL_49_1637 BL_50_1633 BL_51_1629 BL_52_1625 BL_53_1621
+  BL_54_1617 BL_55_1613 BL_56_1609 BL_57_1605 BL_58_1601 BL_59_1597
+  BL_60_1593 BL_61_1589 BL_62_1585 BL__63_1581 BL__64_1577 BL__65_1573
+  BL__66_1569 BL__67_1565 BL__68_1561 BL__69_1557 BL__70_1553 BL__71_1549
+  BL__72_1545 BL__73_1541 BL__74_1537 BL__75_1533 BL__76_1529 BL__77_1525
+  BL__78_1521 BL_79_1517 BL_80_1513 BL_81_1509 BL_82_1505 BL_83_1501
+  BL_84_1497 BL_85_1493 BL_86_1489 BL_87_1485 BL_88_1481 BL_89_1477
+  BL_90_1473 BL_91_1469 BL_92_1465 BL_93_1461 BL_94_1457 BL__95_1453
+  BL__96_1449 BL__97_1445 BL__98_1441 BL__99_1437 BL__100_1433 BL__101_1429
+  BL__102_1425 BL__103_1421 BL__104_1417 BL__105_1413 BL__106_1409
+  BL__107_1405 BL__108_1401 BL__109_1397 BL__110_1393 BL_111_1389 BL_112_1385
+  BL_113_1381 BL_114_1377 BL_115_1373 BL_116_1369 BL_117_1365 BL_118_1361
+  BL_119_1357 BL_120_1353 BL_121_1349 BL_122_1345 BL_123_1341 BL_124_1337
+  BL_125_1333 BL_126_1329 BL__129_1317 BL__130_1313 BL__131_1309 BL__132_1305
+  BL__133_1301 BL__134_1297 BL__135_1293 BL__136_1289 BL__137_1285
+  BL__138_1281 BL__139_1277 BL__140_1273 BL__141_1269 BL__142_1265
+  BL_143_1261 BL_144_1257 BL_145_1253 BL_146_1249 BL_147_1245 BL_148_1241
+  BL_149_1237 BL_150_1233 BL_151_1229 BL_152_1225 BL_153_1221 BL_154_1217
+  BL_155_1213 BL_156_1209 BL_157_1205 BL_158_1201 BL__159_1197 BL__160_1193
+  BL__161_1189 BL__162_1185 BL__163_1181 BL__164_1177 BL__165_1173
+  BL__166_1169 BL__167_1165 BL__168_1161 BL__169_1157 BL__170_1153
+  BL__171_1149 BL__172_1145 BL__173_1141 BL__174_1137 BL_175_1133 BL_176_1129
+  BL_177_1125 BL_178_1121 BL_179_1117 BL_180_1113 BL_181_1109 BL_182_1105
+  BL_183_1101 BL_184_1097 BL_185_1093 BL_186_1089 BL_187_1085 BL_188_1081
+  BL_189_1077 BL_190_1073 BL__191_1069 BL__192_1065 BL__193_1061 BL__194_1057
+  BL__195_1053 BL__196_1049 BL__197_1045 BL__198_1041 BL__199_1037
+  BL__200_1033 BL__201_1029 BL__202_1025 BL__203_1021 BL__204_1017
+  BL__205_1013 BL__206_1009 BL_207_1005 BL_208_1001 BL_209_997 BL_210_993
+  BL_211_989 BL_212_985 BL_213_981 BL_214_977 BL_215_973 BL_216_969
+  BL_217_965 BL_218_961 BL_219_957 BL_220_953 BL_221_949 BL_222_945
+  BL__223_941 BL__224_937 BL__225_933 BL__226_929 BL__227_925 BL__228_921
+  BL__229_917 BL__230_913 BL__231_909 BL__232_905 BL__233_901 BL__234_897
+  BL__235_893 BL__236_889 BL__237_885 BL__238_881 BL_239_877 BL_240_873
+  BL_241_869 BL_242_865 BL_243_861 BL_244_857 BL_245_853 BL_246_849
+  BL_247_845 BL_248_841 BL_249_837 BL_250_833 BL_251_829 BL_252_825
+  BL_253_821 BL_254_817 BL_0_1831 BL_1_1827 BL_2_1823 BL_3_1819 BL_4_1815
+  BL_5_1811 BL_6_1807 BL_7_1803 BL_8_1799 BL_9_1795 BL_10_1791 BL_11_1787
+  BL_12_1783 BL_13_1779 BL_14_1775 BL__15_1771 BL__16_1767 BL__17_1763
+  BL__18_1759 BL__19_1755 BL__20_1751 BL__21_1747 BL__22_1743 BL__23_1739
+  BL__24_1735 BL__25_1731 BL__26_1727 BL__27_1723 BL__28_1719 BL__29_1715
+  BL__30_1711 BL_31_1707 BL_32_1703 BL_33_1699 BL_34_1695 BL_35_1691
+  BL_36_1687 BL_37_1683 BL_38_1679 BL_39_1675 BL_40_1671 BL_41_1667
+  BL_42_1663 BL_43_1659 BL_44_1655 BL_45_1651 BL_46_1647 BL__47_1643
+  BL__48_1639 BL__49_1635 BL__50_1631 BL__51_1627 BL__52_1623 BL__53_1619
+  BL__54_1615 BL__55_1611 BL__56_1607 BL__57_1603 BL__58_1599 BL__59_1595
+  BL__60_1591 BL__61_1587 BL__62_1583 BL_63_1579 BL_64_1575 BL_65_1571
+  BL_66_1567 BL_67_1563 BL_68_1559 BL_69_1555 BL_70_1551 BL_71_1547
+  BL_72_1543 BL_73_1539 BL_74_1535 BL_75_1531 BL_76_1527 BL_77_1523
+  BL_78_1519 BL__79_1515 BL__80_1511 BL__81_1507 BL__82_1503 BL__83_1499
+  BL__84_1495 BL__85_1491 BL__86_1487 BL__87_1483 BL__88_1479 BL__89_1475
+  BL__90_1471 BL__91_1467 BL__92_1463 BL__93_1459 BL__94_1455 BL_95_1451
+  BL_96_1447 BL_97_1443 BL_98_1439 BL_99_1435 BL_100_1431 BL_101_1427
+  BL_102_1423 BL_103_1419 BL_104_1415 BL_105_1411 BL_106_1407 BL_107_1403
+  BL_108_1399 BL_109_1395 BL_110_1391 BL__111_1387 BL__112_1383 BL__113_1379
+  BL__114_1375 BL__115_1371 BL__116_1367 BL__117_1363 BL__118_1359
+  BL__119_1355 BL__120_1351 BL__121_1347 BL__122_1343 BL__123_1339
+  BL__124_1335 BL__125_1331 BL__126_1327 BL_129_1315 BL_130_1311 BL_131_1307
+  BL_132_1303 BL_133_1299 BL_134_1295 BL_135_1291 BL_136_1287 BL_137_1283
+  BL_138_1279 BL_139_1275 BL_140_1271 BL_141_1267 BL_142_1263 BL__143_1259
+  BL__144_1255 BL__145_1251 BL__146_1247 BL__147_1243 BL__148_1239
+  BL__149_1235 BL__150_1231 BL__151_1227 BL__152_1223 BL__153_1219
+  BL__154_1215 BL__155_1211 BL__156_1207 BL__157_1203 BL__158_1199
+  BL_159_1195 BL_160_1191 BL_161_1187 BL_162_1183 BL_163_1179 BL_164_1175
+  BL_165_1171 BL_166_1167 BL_167_1163 BL_168_1159 BL_169_1155 BL_170_1151
+  BL_171_1147 BL_172_1143 BL_173_1139 BL_174_1135 BL__175_1131 BL__176_1127
+  BL__177_1123 BL__178_1119 BL__179_1115 BL__180_1111 BL__181_1107
+  BL__182_1103 BL__183_1099 BL__184_1095 BL__185_1091 BL__186_1087
+  BL__187_1083 BL__188_1079 BL__189_1075 BL__190_1071 BL_191_1067 BL_192_1063
+  BL_193_1059 BL_194_1055 BL_195_1051 BL_196_1047 BL_197_1043 BL_198_1039
+  BL_199_1035 BL_200_1031 BL_201_1027 BL_202_1023 BL_203_1019 BL_204_1015
+  BL_205_1011 BL_206_1007 BL__207_1003 BL__208_999 BL__209_995 BL__210_991
+  BL__211_987 BL__212_983 BL__213_979 BL__214_975 BL__215_971 BL__216_967
+  BL__217_963 BL__218_959 BL__219_955 BL__220_951 BL__221_947 BL__222_943
+  BL_223_939 BL_224_935 BL_225_931 BL_226_927 BL_227_923 BL_228_919
+  BL_229_915 BL_230_911 BL_231_907 BL_232_903 BL_233_899 BL_234_895
+  BL_235_891 BL_236_887 BL_237_883 BL_238_879 BL__239_875 BL__240_871
+  BL__241_867 BL__242_863 BL__243_859 BL__244_855 BL__245_851 BL__246_847
+  BL__247_843 BL__248_839 BL__249_835 BL__250_831 BL__251_827 BL__252_823
+  BL__253_819 BL__254_815 MWLB VSS VSS VDD RA1SHD4096X32MODEL_ROW_16
XI8_0 A0 A0_ GTP_1 GTP_1 GTP_1 OE_ VSS WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD4096X32RIGHT_CAP
.ENDS RA1SHD4096X32
