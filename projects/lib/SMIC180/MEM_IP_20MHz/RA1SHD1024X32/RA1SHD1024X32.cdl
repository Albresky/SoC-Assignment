*
* Copyright 2002 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
*
* Generated by bif2cdl v3.3c
* Version: 2005Q3V1
* Name: High Speed/Density Single-Port SRAM|SMIC 0.18um Logic018 Process
* Comment:
* Configuration:  -instname RA1SHD1024X32 -words 1024 -bits 32 -fre\
* Configuration: quency 20 -ring_width 2 -mux 8 -drive 12 -write_ma\
* Configuration: sk on -wp_size 8 -top_layer met6 -power_type rings\
* Configuration:  -horiz met3 -vert met4 -cust_comment "" -left_bus\
* Configuration: _delim "[" -right_bus_delim "]" -pwr_gnd_rename "V\
* Configuration: DD:VDD,GND:VSS" -prefix "" -pin_space 0.0 -name_ca\
* Configuration: se upper -check_instname on -diodes on -inside_rin\
* Configuration: g_type GND -asvm on
* Codefile:
*
*
** begin lvs.header
** $Revision: 1.2 $
*.SCALE meter
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RA1SHD1024X32CCG BL BL_ WL WP VSS VDD
** RA1SHD1024X32CCG: 6 flat devices **
m1 BL WP CORED VSS N L=0.29U W=0.22U
m2 BL_ WP CORED_ VSS N L=0.29U W=0.22U
m3 CORED_ CORED VDD VDD P L=0.19U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.25U
m5 CORED CORED_ VDD VDD P L=0.19U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.25U
.ENDS RA1SHD1024X32CCG
****
.SUBCKT RA1SHD1024X32FCIO8 GTP OE_ WE VSS VDD
** RA1SHD1024X32FCIO8: 3 flat devices **
d1 VSS GTP DN 0.3364P 2.32U
d2 VSS OE_ DN 0.3364P 2.32U
d3 VSS WE DN 0.3364P 2.32U
.ENDS RA1SHD1024X32FCIO8
****
.SUBCKT RA1SHD1024X32FCSA8 GTP VSS VDD
** RA1SHD1024X32FCSA8: 1 flat devices **
d1 VSS GTP DN 0.3364P 2.32U
.ENDS RA1SHD1024X32FCSA8
****
.SUBCKT RA1SHD1024X32FCCDL A0 A0_ DR DR_ DW DW_ GTP VD YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32FCCDL: 2 flat devices **
d2 VSS VSS DN 0.3364P 2.32U
m1 VDD VSS VD VDD P L=0.18U W=0.22U
.ENDS RA1SHD1024X32FCCDL
****
.SUBCKT RA1SHD1024X32LEFT_CAP A0 A0_ DR DR_ DW DW_ GTP GTP_0 GTP_1 OE_ WE WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73
+  WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85
+  WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97
+  WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108
+  WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118
+  WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32LEFT_CAP: 792 flat devices **
XI0_0 GTP OE_ WE VSS VDD RA1SHD1024X32FCIO8
XI0_1 GTP_0 VSS VDD RA1SHD1024X32FCSA8
XI0_10 BL BL WL_6 WL_6 VSS VDD RA1SHD1024X32CCG
XI0_100 BL BL WL_96 WL_96 VSS VDD RA1SHD1024X32CCG
XI0_101 BL BL WL_97 WL_97 VSS VDD RA1SHD1024X32CCG
XI0_102 BL BL WL_98 WL_98 VSS VDD RA1SHD1024X32CCG
XI0_103 BL BL WL_99 WL_99 VSS VDD RA1SHD1024X32CCG
XI0_104 BL BL WL_100 WL_100 VSS VDD RA1SHD1024X32CCG
XI0_105 BL BL WL_101 WL_101 VSS VDD RA1SHD1024X32CCG
XI0_106 BL BL WL_102 WL_102 VSS VDD RA1SHD1024X32CCG
XI0_107 BL BL WL_103 WL_103 VSS VDD RA1SHD1024X32CCG
XI0_108 BL BL WL_104 WL_104 VSS VDD RA1SHD1024X32CCG
XI0_109 BL BL WL_105 WL_105 VSS VDD RA1SHD1024X32CCG
XI0_11 BL BL WL_7 WL_7 VSS VDD RA1SHD1024X32CCG
XI0_110 BL BL WL_106 WL_106 VSS VDD RA1SHD1024X32CCG
XI0_111 BL BL WL_107 WL_107 VSS VDD RA1SHD1024X32CCG
XI0_112 BL BL WL_108 WL_108 VSS VDD RA1SHD1024X32CCG
XI0_113 BL BL WL_109 WL_109 VSS VDD RA1SHD1024X32CCG
XI0_114 BL BL WL_110 WL_110 VSS VDD RA1SHD1024X32CCG
XI0_115 BL BL WL_111 WL_111 VSS VDD RA1SHD1024X32CCG
XI0_116 BL BL WL_112 WL_112 VSS VDD RA1SHD1024X32CCG
XI0_117 BL BL WL_113 WL_113 VSS VDD RA1SHD1024X32CCG
XI0_118 BL BL WL_114 WL_114 VSS VDD RA1SHD1024X32CCG
XI0_119 BL BL WL_115 WL_115 VSS VDD RA1SHD1024X32CCG
XI0_12 BL BL WL_8 WL_8 VSS VDD RA1SHD1024X32CCG
XI0_120 BL BL WL_116 WL_116 VSS VDD RA1SHD1024X32CCG
XI0_121 BL BL WL_117 WL_117 VSS VDD RA1SHD1024X32CCG
XI0_122 BL BL WL_118 WL_118 VSS VDD RA1SHD1024X32CCG
XI0_123 BL BL WL_119 WL_119 VSS VDD RA1SHD1024X32CCG
XI0_124 BL BL WL_120 WL_120 VSS VDD RA1SHD1024X32CCG
XI0_125 BL BL WL_121 WL_121 VSS VDD RA1SHD1024X32CCG
XI0_126 BL BL WL_122 WL_122 VSS VDD RA1SHD1024X32CCG
XI0_127 BL BL WL_123 WL_123 VSS VDD RA1SHD1024X32CCG
XI0_128 BL BL WL_124 WL_124 VSS VDD RA1SHD1024X32CCG
XI0_129 BL BL WL_125 WL_125 VSS VDD RA1SHD1024X32CCG
XI0_13 BL BL WL_9 WL_9 VSS VDD RA1SHD1024X32CCG
XI0_130 BL BL WL_126 WL_126 VSS VDD RA1SHD1024X32CCG
XI0_131 BL BL VSS VSS VSS VDD RA1SHD1024X32CCG
XI0_132 BL BL VSS VSS VSS VDD RA1SHD1024X32CCG
XI0_133 BL BL VSS VSS VSS VDD RA1SHD1024X32CCG
XI0_14 BL BL WL_10 WL_10 VSS VDD RA1SHD1024X32CCG
XI0_15 BL BL WL_11 WL_11 VSS VDD RA1SHD1024X32CCG
XI0_16 BL BL WL_12 WL_12 VSS VDD RA1SHD1024X32CCG
XI0_17 BL BL WL_13 WL_13 VSS VDD RA1SHD1024X32CCG
XI0_18 BL BL WL_14 WL_14 VSS VDD RA1SHD1024X32CCG
XI0_19 BL BL WL_15 WL_15 VSS VDD RA1SHD1024X32CCG
XI0_2 A0 A0_ DR DR_ DW DW_ GTP_1 BL YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SHD1024X32FCCDL
XI0_20 BL BL WL_16 WL_16 VSS VDD RA1SHD1024X32CCG
XI0_21 BL BL WL_17 WL_17 VSS VDD RA1SHD1024X32CCG
XI0_22 BL BL WL_18 WL_18 VSS VDD RA1SHD1024X32CCG
XI0_23 BL BL WL_19 WL_19 VSS VDD RA1SHD1024X32CCG
XI0_24 BL BL WL_20 WL_20 VSS VDD RA1SHD1024X32CCG
XI0_25 BL BL WL_21 WL_21 VSS VDD RA1SHD1024X32CCG
XI0_26 BL BL WL_22 WL_22 VSS VDD RA1SHD1024X32CCG
XI0_27 BL BL WL_23 WL_23 VSS VDD RA1SHD1024X32CCG
XI0_28 BL BL WL_24 WL_24 VSS VDD RA1SHD1024X32CCG
XI0_29 BL BL WL_25 WL_25 VSS VDD RA1SHD1024X32CCG
XI0_3 BL BL WL WL VSS VDD RA1SHD1024X32CCG
XI0_30 BL BL WL_26 WL_26 VSS VDD RA1SHD1024X32CCG
XI0_31 BL BL WL_27 WL_27 VSS VDD RA1SHD1024X32CCG
XI0_32 BL BL WL_28 WL_28 VSS VDD RA1SHD1024X32CCG
XI0_33 BL BL WL_29 WL_29 VSS VDD RA1SHD1024X32CCG
XI0_34 BL BL WL_30 WL_30 VSS VDD RA1SHD1024X32CCG
XI0_35 BL BL WL_31 WL_31 VSS VDD RA1SHD1024X32CCG
XI0_36 BL BL WL_32 WL_32 VSS VDD RA1SHD1024X32CCG
XI0_37 BL BL WL_33 WL_33 VSS VDD RA1SHD1024X32CCG
XI0_38 BL BL WL_34 WL_34 VSS VDD RA1SHD1024X32CCG
XI0_39 BL BL WL_35 WL_35 VSS VDD RA1SHD1024X32CCG
XI0_4 BL BL WL_0 WL_0 VSS VDD RA1SHD1024X32CCG
XI0_40 BL BL WL_36 WL_36 VSS VDD RA1SHD1024X32CCG
XI0_41 BL BL WL_37 WL_37 VSS VDD RA1SHD1024X32CCG
XI0_42 BL BL WL_38 WL_38 VSS VDD RA1SHD1024X32CCG
XI0_43 BL BL WL_39 WL_39 VSS VDD RA1SHD1024X32CCG
XI0_44 BL BL WL_40 WL_40 VSS VDD RA1SHD1024X32CCG
XI0_45 BL BL WL_41 WL_41 VSS VDD RA1SHD1024X32CCG
XI0_46 BL BL WL_42 WL_42 VSS VDD RA1SHD1024X32CCG
XI0_47 BL BL WL_43 WL_43 VSS VDD RA1SHD1024X32CCG
XI0_48 BL BL WL_44 WL_44 VSS VDD RA1SHD1024X32CCG
XI0_49 BL BL WL_45 WL_45 VSS VDD RA1SHD1024X32CCG
XI0_5 BL BL WL_1 WL_1 VSS VDD RA1SHD1024X32CCG
XI0_50 BL BL WL_46 WL_46 VSS VDD RA1SHD1024X32CCG
XI0_51 BL BL WL_47 WL_47 VSS VDD RA1SHD1024X32CCG
XI0_52 BL BL WL_48 WL_48 VSS VDD RA1SHD1024X32CCG
XI0_53 BL BL WL_49 WL_49 VSS VDD RA1SHD1024X32CCG
XI0_54 BL BL WL_50 WL_50 VSS VDD RA1SHD1024X32CCG
XI0_55 BL BL WL_51 WL_51 VSS VDD RA1SHD1024X32CCG
XI0_56 BL BL WL_52 WL_52 VSS VDD RA1SHD1024X32CCG
XI0_57 BL BL WL_53 WL_53 VSS VDD RA1SHD1024X32CCG
XI0_58 BL BL WL_54 WL_54 VSS VDD RA1SHD1024X32CCG
XI0_59 BL BL WL_55 WL_55 VSS VDD RA1SHD1024X32CCG
XI0_6 BL BL WL_2 WL_2 VSS VDD RA1SHD1024X32CCG
XI0_60 BL BL WL_56 WL_56 VSS VDD RA1SHD1024X32CCG
XI0_61 BL BL WL_57 WL_57 VSS VDD RA1SHD1024X32CCG
XI0_62 BL BL WL_58 WL_58 VSS VDD RA1SHD1024X32CCG
XI0_63 BL BL WL_59 WL_59 VSS VDD RA1SHD1024X32CCG
XI0_64 BL BL WL_60 WL_60 VSS VDD RA1SHD1024X32CCG
XI0_65 BL BL WL_61 WL_61 VSS VDD RA1SHD1024X32CCG
XI0_66 BL BL WL_62 WL_62 VSS VDD RA1SHD1024X32CCG
XI0_67 BL BL WL_63 WL_63 VSS VDD RA1SHD1024X32CCG
XI0_68 BL BL WL_64 WL_64 VSS VDD RA1SHD1024X32CCG
XI0_69 BL BL WL_65 WL_65 VSS VDD RA1SHD1024X32CCG
XI0_7 BL BL WL_3 WL_3 VSS VDD RA1SHD1024X32CCG
XI0_70 BL BL WL_66 WL_66 VSS VDD RA1SHD1024X32CCG
XI0_71 BL BL WL_67 WL_67 VSS VDD RA1SHD1024X32CCG
XI0_72 BL BL WL_68 WL_68 VSS VDD RA1SHD1024X32CCG
XI0_73 BL BL WL_69 WL_69 VSS VDD RA1SHD1024X32CCG
XI0_74 BL BL WL_70 WL_70 VSS VDD RA1SHD1024X32CCG
XI0_75 BL BL WL_71 WL_71 VSS VDD RA1SHD1024X32CCG
XI0_76 BL BL WL_72 WL_72 VSS VDD RA1SHD1024X32CCG
XI0_77 BL BL WL_73 WL_73 VSS VDD RA1SHD1024X32CCG
XI0_78 BL BL WL_74 WL_74 VSS VDD RA1SHD1024X32CCG
XI0_79 BL BL WL_75 WL_75 VSS VDD RA1SHD1024X32CCG
XI0_8 BL BL WL_4 WL_4 VSS VDD RA1SHD1024X32CCG
XI0_80 BL BL WL_76 WL_76 VSS VDD RA1SHD1024X32CCG
XI0_81 BL BL WL_77 WL_77 VSS VDD RA1SHD1024X32CCG
XI0_82 BL BL WL_78 WL_78 VSS VDD RA1SHD1024X32CCG
XI0_83 BL BL WL_79 WL_79 VSS VDD RA1SHD1024X32CCG
XI0_84 BL BL WL_80 WL_80 VSS VDD RA1SHD1024X32CCG
XI0_85 BL BL WL_81 WL_81 VSS VDD RA1SHD1024X32CCG
XI0_86 BL BL WL_82 WL_82 VSS VDD RA1SHD1024X32CCG
XI0_87 BL BL WL_83 WL_83 VSS VDD RA1SHD1024X32CCG
XI0_88 BL BL WL_84 WL_84 VSS VDD RA1SHD1024X32CCG
XI0_89 BL BL WL_85 WL_85 VSS VDD RA1SHD1024X32CCG
XI0_9 BL BL WL_5 WL_5 VSS VDD RA1SHD1024X32CCG
XI0_90 BL BL WL_86 WL_86 VSS VDD RA1SHD1024X32CCG
XI0_91 BL BL WL_87 WL_87 VSS VDD RA1SHD1024X32CCG
XI0_92 BL BL WL_88 WL_88 VSS VDD RA1SHD1024X32CCG
XI0_93 BL BL WL_89 WL_89 VSS VDD RA1SHD1024X32CCG
XI0_94 BL BL WL_90 WL_90 VSS VDD RA1SHD1024X32CCG
XI0_95 BL BL WL_91 WL_91 VSS VDD RA1SHD1024X32CCG
XI0_96 BL BL WL_92 WL_92 VSS VDD RA1SHD1024X32CCG
XI0_97 BL BL WL_93 WL_93 VSS VDD RA1SHD1024X32CCG
XI0_98 BL BL WL_94 WL_94 VSS VDD RA1SHD1024X32CCG
XI0_99 BL BL WL_95 WL_95 VSS VDD RA1SHD1024X32CCG
.ENDS RA1SHD1024X32LEFT_CAP
****
.SUBCKT RA1SHD1024X32FCBWRO8 BWEN D Q VSS VDD
** RA1SHD1024X32FCBWRO8: 2 flat devices **
d1 VSS Q DN 0.3364P 2.32U
d2 VSS D DN 0.3364P 2.32U
.ENDS RA1SHD1024X32FCBWRO8
****
.SUBCKT RA1SHD1024X32IO8 BWE BWEMX BWEN D DI_ DPN DPU DW DW_ D_ GBWEN GTP OE_
+  Q QI SP STUBWE STUBWEI UTIDMX WE VSS VDD
** RA1SHD1024X32IO8: 60 flat devices **
m1 QI DPU VSS VSS N L=0.18U W=3.47U
m10 QPD OEI_ VSS VSS N L=0.18U W=0.72U
m11 QIL QI VDD VDD P L=0.18U W=1.27U
m12 QIL QI VSS VSS N L=0.18U W=0.72U
m13 SPN SP VDD VDD P L=0.18U W=0.47U
m14 SPN SP VSS VSS N L=0.18U W=0.31U
m15 DWPD GTPND DWI VSS N L=0.18U W=0.72U
m16 DWPD DW VDD VDD P L=0.27U W=0.22U
m17 DWPD DW VSS VSS N L=0.54U W=0.22U
m18 DWPD GTP DWI VDD P L=0.18U W=0.91U
m19 DW_PU GTPND DNWI VSS N L=0.18U W=0.72U
m2 QI DPN VDD VDD P L=0.18U W=9.12U
m20 DW_PU GTP DNWI VDD P L=0.18U W=0.91U
m21 GTPND GTP VDD VDD P L=0.18U W=0.5U
m22 GTPND GTP VSS VSS N L=0.18U W=0.34U
m23 DI DI_ VDD VDD P L=0.18U W=1.82U
m24 DI DI_ VSS VSS N L=0.18U W=0.89U
m25 DN DI VDD VDD P L=0.18U W=1.25U
m26 DN DI VSS VSS N L=0.18U W=0.61U
m27 WEI N58 VDD VDD P L=0.18U W=1.47U
m28 WEI N58 VSS VSS N L=0.18U W=0.86U
m29 OEI OEI_ VDD VDD P L=0.18U W=1.23U
m3 Q QPU VDD VDD P L=0.18U W=10.8U
m30 OEI OEI_ VSS VSS N L=0.18U W=0.64U
m31 QI SP N84 VDD P L=0.18U W=2U
m32 N84 QIL VDD VDD P L=0.18U W=2U
m33 QI SPN N83 VSS N L=0.18U W=2U
m34 N83 QIL VSS VSS N L=0.18U W=2U
m35 N41 OE_ VDD VDD P L=0.18U W=0.78U
m36 N41 OE_ VSS VSS N L=0.18U W=0.4U
m37 N58 WE VDD VDD P L=0.18U W=0.58U
m38 N58 WE VSS VSS N L=0.18U W=0.29U
m39 DWI WEI VDD VDD P L=0.18U W=1.77U
m4 Q QPD VSS VSS N L=0.18U W=7.2U
m40 N85 WEI VSS VSS N L=0.18U W=1.58U
m41 DWI DI VDD VDD P L=0.18U W=1.77U
m42 DWI DI N85 VSS N L=0.18U W=1.58U
m43 DNWI WEI VDD VDD P L=0.18U W=1.77U
m44 N86 WEI VSS VSS N L=0.18U W=1.58U
m45 DNWI DN VDD VDD P L=0.18U W=1.77U
m46 DNWI DN N86 VSS N L=0.18U W=1.58U
m47 D_ D VDD VDD P L=0.18U W=0.71U
m48 D_ D VSS VSS N L=0.18U W=0.35U
m49 QPU OEI_ QI VDD P L=0.18U W=0.34U
m5 OEI_ N41 VDD VDD P L=0.18U W=2.18U
m50 QPD OEI QI VSS N L=0.18U W=0.65U
m51 DW DWPD VDD VDD P L=0.18U W=5.98U
m52 DW DWPD VSS VSS N L=0.18U W=2.95U
m53 DW_PU DW_ VDD VDD P L=0.27U W=0.22U
m54 DW_PU DW_ VSS VSS N L=0.54U W=0.22U
m55 DW_ DW_PU VDD VDD P L=0.18U W=5.98U
m56 DW_ DW_PU VSS VSS N L=0.18U W=2.95U
m57 N87 VSS VDD VDD P L=0.18U W=0.44U
m58 BWE VSS VSS VSS N L=0.18U W=0.22U
m59 BWE GBWEN N87 VDD P L=0.18U W=0.44U
m6 OEI_ N41 VSS VSS N L=0.18U W=1.11U
m60 BWE GBWEN VSS VSS N L=0.18U W=0.22U
m7 QPD OEI_ QI VDD P L=0.18U W=6.92U
m8 QPU OEI QI VSS N L=0.18U W=3.24U
m9 QPU OEI VDD VDD P L=0.18U W=1.74U
.ENDS RA1SHD1024X32IO8
****
.SUBCKT RA1SHD1024X32IOX BWE BWEN D DPN DPU DW DW_ D_ GTP OE_ Q QI SP VSS VDD
** RA1SHD1024X32IOX: 60 flat devices **
XI0_0 BWE VSS BWEN D D_ DPN DPU DW DW_ D_ BWEN GTP OE_ Q QI SP VSS VSS VSS BWE
+  VSS VDD RA1SHD1024X32IO8
.ENDS RA1SHD1024X32IOX
****
.SUBCKT RA1SHD1024X32SA8 DPN DPU DR DR_ DW DW_ GTP SP VSS VDD
** RA1SHD1024X32SA8: 42 flat devices **
d42 VSS GTP DN 0.3364P 2.32U
m1 N23 SRCD VSS VSS N L=0.18U W=1.5U
m10 DPN SDN VDD VDD P L=0.18U W=1.54U
m11 DPN SDN VSS VSS N L=0.18U W=2.9U
m12 SP SPN VDD VDD P L=0.18U W=1.98U
m13 SP SPN VSS VSS N L=0.18U W=1.33U
m14 GTPN GTP VDD VDD P L=0.18U W=1U
m15 GTPN GTP VSS VSS N L=0.18U W=0.31U
m16 ND1 GTPN VDD VDD P L=0.18U W=0.58U
m17 ND1 GTPN VSS VSS N L=0.18U W=0.33U
m18 ND2 ND1 VDD VDD P L=0.18U W=1.65U
m19 ND2 ND1 VSS VSS N L=0.18U W=0.71U
m2 SD SP DR VDD P L=0.19U W=3.2U
m20 N41 DRP VSS VSS N L=0.18U W=1.22U
m21 SPN GTPN N41 VSS N L=0.18U W=0.83U
m22 SPN DRP VDD VDD P L=0.18U W=1.11U
m23 SPN GTPN VDD VDD P L=0.18U W=0.66U
m24 DRP ND2 VDD VDD P L=0.18U W=3U
m25 DRP ND2 VSS VSS N L=0.18U W=2.01U
m26 DR_ DRP VDD VDD P L=0.18U W=3.65U
m27 DR DRP VDD VDD P L=0.18U W=3.65U
m28 DR DRP DR_ VDD P L=0.18U W=4.68U
m29 SD_ SD SRC VSS N L=0.26U W=3.56U
m3 SD_ SP DR_ VDD P L=0.19U W=3.2U
m30 SD SD_ SRC VSS N L=0.26U W=3.56U
m31 SD_ SD SRC VSS N L=0.26U W=3.56U
m32 SD SD_ SRC VSS N L=0.26U W=3.56U
m33 SRC GTPN N23 VSS N L=0.18U W=1.65U
m34 SRCD SRCPU VDD VDD P L=0.18U W=0.62U
m35 SRCD SRCPU VSS VSS N L=0.18U W=0.22U
m36 SRCPU DRP VDD VDD P L=0.18U W=0.91U
m37 SRCPU DRP VSS VSS N L=0.18U W=0.33U
m38 VDD SRCPU SRC VSS N L=0.18U W=1.66U
m39 SD SRCD SD_ VDD P L=0.18U W=0.68U
m4 SD_ SD VDD VDD P L=0.18U W=0.68U
m40 SRC GTPN N53 VSS N L=0.18U W=1.65U
m41 N53 SRCD VSS VSS N L=0.18U W=1.5U
m5 SD SD_ VDD VDD P L=0.18U W=0.68U
m6 SDN SD VDD VDD P L=0.18U W=1.64U
m7 SDN SD VSS VSS N L=0.18U W=0.58U
m8 DPU SD_ VDD VDD P L=0.18U W=1.64U
m9 DPU SD_ VSS VSS N L=0.18U W=0.58U
.ENDS RA1SHD1024X32SA8
****
.SUBCKT RA1SHD1024X32CD A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0 G1
+  GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** RA1SHD1024X32CD: 43 flat devices **
m1 BL0_ CS0 DR_ VDD P L=0.18U W=3.24U
m10 BL1_ BL1PD VSS VSS N L=0.18U W=6.72U
m11 BL1_PD CS1 DW_ VDD P L=0.18U W=1.72U
m12 BL1_PD CS1 VSS VSS N L=0.18U W=0.88U
m13 BL1_ CS1 DR_ VDD P L=0.18U W=3.24U
m14 BL1PD CS1 DW VDD P L=0.18U W=1.72U
m15 BL1PD CS1 VSS VSS N L=0.18U W=0.88U
m16 BL1 BL1_PD VSS VSS N L=0.18U W=6.72U
m17 BL0_ YI VDD VDD P L=0.18U W=11.8U
m18 BL0 YI VDD VDD P L=0.18U W=11.8U
m19 BL0 YI BL0_ VDD P L=0.18U W=11.8U
m2 BL0 BL0PD VSS VSS N L=0.18U W=6.72U
m20 BL1 YI VDD VDD P L=0.18U W=11.8U
m21 BL1_ YI VDD VDD P L=0.18U W=11.8U
m22 BL1_ YI BL1 VDD P L=0.18U W=11.8U
m23 CS0 A0_ VDD VDD P L=0.18U W=2.09U
m24 N65 A0_ VSS VSS N L=0.18U W=2.13U
m25 CS0 YI VDD VDD P L=0.18U W=2.09U
m26 CS0 YI N65 VSS N L=0.18U W=2.13U
m27 CS1 A0 VDD VDD P L=0.18U W=2.09U
m28 N66 A0 VSS VSS N L=0.18U W=2.13U
m29 CS1 YI VDD VDD P L=0.18U W=2.09U
m3 BL0_PD CS0 DW VDD P L=0.18U W=1.72U
m30 CS1 YI N66 VSS N L=0.18U W=2.13U
m31 YCDSEL_ G0 VDD VDD P L=0.18U W=0.81U
m32 N67 G0 VSS VSS N L=0.18U W=0.76U
m33 YCDSEL_ G1 VDD VDD P L=0.18U W=0.81U
m34 YCDSEL_ G1 N67 VSS N L=0.18U W=0.76U
m35 YCDSEL YCDSEL_ VDD VDD P L=0.18U W=0.47U
m36 YCDSEL YCDSEL_ VSS VSS N L=0.18U W=0.22U
m37 N37 YCDSEL_ GTP VDD P L=0.18U W=0.66U
m38 N37 YCDSEL_ VSS VSS N L=0.18U W=1.06U
m39 YI WL1_EN_ VDD VDD P L=0.18U W=13.14U
m4 BL0_PD CS0 VSS VSS N L=0.18U W=0.88U
m40 YI WL1_EN_ VSS VSS N L=0.18U W=7.69U
m41 WL1_EN_ N37 VDD VDD P L=0.18U W=4U
m42 WL1_EN_ N37 VSS VSS N L=0.18U W=2.97U
m43 N37 YCDSEL GTP VSS N L=0.18U W=0.66U
m5 BL0 CS0 DR VDD P L=0.18U W=3.24U
m6 BL0PD CS0 DW_ VDD P L=0.18U W=1.72U
m7 BL0PD CS0 VSS VSS N L=0.18U W=0.88U
m8 BL0_ BL0_PD VSS VSS N L=0.18U W=6.72U
m9 BL1 CS1 DR VDD P L=0.18U W=3.24U
.ENDS RA1SHD1024X32CD
****
.SUBCKT RA1SHD1024X32CDX A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0
+  G1 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32CDX: 43 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0 G1 GTP DR DR_ DW DW_
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32CD
.ENDS RA1SHD1024X32CDX
****
.SUBCKT RA1SHD1024X32MUX_CD_ODD A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0__0
+  BL0__1 BL0__2 BL1 BL1_ BL1_0 BL1_1 BL1_2 BL1__0 BL1__1 BL1__2 DRSA DRSA_0
+  DWSA DWSA_0 GTP STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0
+  STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32MUX_CD_ODD: 172 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL1 BL1_ STUBDR DRSA STUBDR_ STUBDW DWSA STUBDW_ YP0_3
+  VDD GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32CD
XI1_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 STUBDR STUBDR STUBDR_ STUBDW STUBDW
+  STUBDW_ YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD1024X32CDX
XI2_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 STUBDR STUBDR_ STUBDR_ STUBDW STUBDW_
+  STUBDW_ YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD1024X32CDX
XI3_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 STUBDR DRSA_0 STUBDR_ STUBDW DWSA_0
+  STUBDW_ YP0_0 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD1024X32CDX
.ENDS RA1SHD1024X32MUX_CD_ODD
****
.SUBCKT RA1SHD1024X32CCP BL BL_ WL WP VSS VDD
** RA1SHD1024X32CCP: 6 flat devices **
m1 BL WP CORED VSS N L=0.29U W=0.22U
m2 BL_ WP CORED_ VSS N L=0.29U W=0.22U
m3 CORED_ CORED VDD VDD P L=0.19U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.25U
m5 CORED CORED_ VDD VDD P L=0.19U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.25U
.ENDS RA1SHD1024X32CCP
****
.SUBCKT RA1SHD1024X32BIT_MUX_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WP VSS VDD
** RA1SHD1024X32BIT_MUX_1: 48 flat devices **
XI0_0 BL BL_ WL WP VSS VDD RA1SHD1024X32CCG
XI1_0 BL_0 BL__0 WL WP VSS VDD RA1SHD1024X32CCP
XI2_0 BL_1 BL__1 WL WP VSS VDD RA1SHD1024X32CCP
XI3_0 BL_2 BL__2 WL WP VSS VDD RA1SHD1024X32CCG
XI4_0 BL_3 BL__3 WL WP VSS VDD RA1SHD1024X32CCG
XI5_0 BL_4 BL__4 WL WP VSS VDD RA1SHD1024X32CCP
XI6_0 BL_5 BL__5 WL WP VSS VDD RA1SHD1024X32CCP
XI7_0 BL_6 BL__6 WL WP VSS VDD RA1SHD1024X32CCG
.ENDS RA1SHD1024X32BIT_MUX_1
****
.SUBCKT RA1SHD1024X32BIT_MUX_0 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WP VSS VDD
** RA1SHD1024X32BIT_MUX_0: 48 flat devices **
XI0_0 BL BL_ WL WP VSS VDD RA1SHD1024X32CCG
XI1_0 BL_0 BL__0 WL WP VSS VDD RA1SHD1024X32CCP
XI2_0 BL_1 BL__1 WL WP VSS VDD RA1SHD1024X32CCP
XI3_0 BL_2 BL__2 WL WP VSS VDD RA1SHD1024X32CCG
XI4_0 BL_3 BL__3 WL WP VSS VDD RA1SHD1024X32CCG
XI5_0 BL_4 BL__4 WL WP VSS VDD RA1SHD1024X32CCP
XI6_0 BL_5 BL__5 WL WP VSS VDD RA1SHD1024X32CCP
XI7_0 BL_6 BL__6 WL WP VSS VDD RA1SHD1024X32CCG
.ENDS RA1SHD1024X32BIT_MUX_0
****
.SUBCKT RA1SHD1024X32BIT_COL BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9
+  WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21
+  WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33
+  WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45
+  WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57
+  WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69
+  WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81
+  WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93
+  WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104
+  WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113 WP_114
+  WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123 WP_124
+  WP_125 WP_126 VSS VDD
** RA1SHD1024X32BIT_COL: 6144 flat devices **
XI0_0 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL WP VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_0 WP_0 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_10 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_9 WP_9 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_100 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_99 WP_99 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_101 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_100 WP_100 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_102 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_101 WP_101 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_103 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_102 WP_102 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_104 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_103 WP_103 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_105 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_104 WP_104 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_106 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_105 WP_105 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_107 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_106 WP_106 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_108 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_107 WP_107 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_109 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_108 WP_108 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_11 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_10 WP_10 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_110 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_109 WP_109 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_111 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_110 WP_110 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_112 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_111 WP_111 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_113 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_112 WP_112 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_114 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_113 WP_113 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_115 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_114 WP_114 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_116 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_115 WP_115 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_117 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_116 WP_116 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_118 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_117 WP_117 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_119 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_118 WP_118 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_12 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_11 WP_11 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_120 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_119 WP_119 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_121 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_120 WP_120 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_122 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_121 WP_121 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_123 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_122 WP_122 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_124 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_123 WP_123 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_125 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_124 WP_124 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_126 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_125 WP_125 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_127 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 WL_126 WP_126 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_13 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_12 WP_12 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_14 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_13 WP_13 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_15 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_14 WP_14 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_16 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_15 WP_15 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_17 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_16 WP_16 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_18 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_17 WP_17 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_19 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_18 WP_18 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_2 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_1 WP_1 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_20 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_19 WP_19 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_21 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_20 WP_20 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_22 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_21 WP_21 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_23 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_22 WP_22 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_24 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_23 WP_23 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_25 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_24 WP_24 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_26 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_25 WP_25 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_27 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_26 WP_26 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_28 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_27 WP_27 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_29 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_28 WP_28 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_3 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_2 WP_2 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_30 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_29 WP_29 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_31 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_30 WP_30 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_32 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_31 WP_31 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_33 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_32 WP_32 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_34 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_33 WP_33 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_35 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_34 WP_34 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_36 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_35 WP_35 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_37 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_36 WP_36 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_38 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_37 WP_37 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_39 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_38 WP_38 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_4 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_3 WP_3 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_40 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_39 WP_39 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_41 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_40 WP_40 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_42 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_41 WP_41 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_43 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_42 WP_42 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_44 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_43 WP_43 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_45 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_44 WP_44 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_46 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_45 WP_45 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_47 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_46 WP_46 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_48 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_47 WP_47 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_49 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_48 WP_48 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_5 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_4 WP_4 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_50 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_49 WP_49 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_51 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_50 WP_50 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_52 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_51 WP_51 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_53 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_52 WP_52 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_54 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_53 WP_53 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_55 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_54 WP_54 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_56 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_55 WP_55 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_57 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_56 WP_56 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_58 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_57 WP_57 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_59 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_58 WP_58 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_6 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_5 WP_5 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_60 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_59 WP_59 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_61 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_60 WP_60 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_62 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_61 WP_61 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_63 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_62 WP_62 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_64 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_63 WP_63 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_65 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_64 WP_64 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_66 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_65 WP_65 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_67 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_66 WP_66 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_68 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_67 WP_67 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_69 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_68 WP_68 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_7 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_6 WP_6 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_70 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_69 WP_69 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_71 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_70 WP_70 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_72 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_71 WP_71 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_73 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_72 WP_72 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_74 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_73 WP_73 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_75 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_74 WP_74 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_76 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_75 WP_75 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_77 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_76 WP_76 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_78 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_77 WP_77 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_79 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_78 WP_78 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_8 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_7 WP_7 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_80 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_79 WP_79 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_81 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_80 WP_80 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_82 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_81 WP_81 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_83 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_82 WP_82 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_84 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_83 WP_83 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_85 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_84 WP_84 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_86 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_85 WP_85 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_87 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_86 WP_86 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_88 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_87 WP_87 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_89 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_88 WP_88 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_9 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_8 WP_8 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_90 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_89 WP_89 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_91 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_90 WP_90 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_92 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_91 WP_91 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_93 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_92 WP_92 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_94 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_93 WP_93 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_95 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_94 WP_94 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_96 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_95 WP_95 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_97 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_96 WP_96 VSS VDD RA1SHD1024X32BIT_MUX_1
XI0_98 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_97 WP_97 VSS VDD RA1SHD1024X32BIT_MUX_0
XI0_99 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_98 WP_98 VSS VDD RA1SHD1024X32BIT_MUX_1
.ENDS RA1SHD1024X32BIT_COL
****
.SUBCKT RA1SHD1024X32MCOL_ODD_RO8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WP WP_0 WP_1 WP_2 WP_3
+  WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16
+  WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28
+  WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40
+  WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52
+  WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64
+  WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76
+  WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88
+  WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100
+  WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110
+  WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120
+  WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32MCOL_ODD_RO8: 6420 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SHD1024X32FCBWRO8
XI0_1 BWE BWEN D DPN DPU STUBDW STUBDW_ D_ GTP OE_ Q QI SP VSS VDD
+  RA1SHD1024X32IOX
XI0_2 DPN DPU STUBDR STUBDR_ STUBDW STUBDW_ GTP_0 SP VSS VDD RA1SHD1024X32SA8
XI0_3 A0 A0_ BL_ BL BL_2 BL__3 BL_6 BL__2 BL_3 BL__6 BL_0 BL__0 BL__1 BL_4
+  BL__5 BL_1 BL__4 BL_5 VSS VSS VSS VSS GTP_1 STUBDR STUBDR_ STUBDR_0
+  STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32MUX_CD_ODD
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11
+  WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23
+  WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35
+  WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47
+  WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59
+  WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71
+  WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83
+  WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95
+  WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106
+  WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116
+  WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 VSS
+  VDD RA1SHD1024X32BIT_COL
.ENDS RA1SHD1024X32MCOL_ODD_RO8
****
.SUBCKT RA1SHD1024X32FCBWM8 BWEN D Q VSS VDD
** RA1SHD1024X32FCBWM8: 2 flat devices **
d1 VSS Q DN 0.3364P 2.32U
d2 VSS D DN 0.3364P 2.32U
.ENDS RA1SHD1024X32FCBWM8
****
.SUBCKT RA1SHD1024X32MUX_CD_EVEN A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0__0
+  BL0__1 BL0__2 BL1 BL1_ BL1_0 BL1_1 BL1_2 BL1__0 BL1__1 BL1__2 DRSA DRSA_0
+  DRSA_1 DRSA_2 DWSA DWSA_0 DWSA_1 DWSA_2 GTP STUBDR STUBDR_ STUBDW STUBDW_
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32MUX_CD_EVEN: 172 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL1 BL1_ DRSA_0 DRSA DRSA_1 DWSA_0 DWSA DWSA_1 YP0_0 VDD
+  GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32CDX
XI1_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 DRSA_0 DRSA_0 DRSA_1 DWSA_0 DWSA_0
+  DWSA_1 YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD1024X32CDX
XI2_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 DRSA_0 DRSA_1 DRSA_1 DWSA_0 DWSA_1
+  DWSA_1 YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD1024X32CDX
XI3_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 DRSA_0 DRSA_2 DRSA_1 DWSA_0 DWSA_2
+  DWSA_1 YP0_3 VDD GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32CD
.ENDS RA1SHD1024X32MUX_CD_EVEN
****
.SUBCKT RA1SHD1024X32MCOL_EVEN_M8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WP WP_0 WP_1 WP_2 WP_3
+  WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16
+  WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28
+  WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40
+  WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52
+  WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64
+  WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76
+  WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88
+  WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100
+  WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110
+  WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120
+  WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32MCOL_EVEN_M8: 6420 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SHD1024X32FCBWM8
XI0_1 BWE BWEN D DPN DPU STUBDW_0 STUBDW__0 D_ GTP OE_ Q QI SP VSS VDD
+  RA1SHD1024X32IOX
XI0_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_0 SP VSS VDD
+  RA1SHD1024X32SA8
XI0_3 A0 A0_ BL_ BL BL_2 BL__3 BL_6 BL__2 BL_3 BL__6 BL_0 BL__0 BL__1 BL_4
+  BL__5 BL_1 BL__4 BL_5 VSS STUBDR_0 STUBDR__0 VSS VSS STUBDW_0 STUBDW__0 VSS
+  GTP_1 STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD1024X32MUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11
+  WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23
+  WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35
+  WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47
+  WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59
+  WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71
+  WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83
+  WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95
+  WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106
+  WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116
+  WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 VSS
+  VDD RA1SHD1024X32BIT_COL
.ENDS RA1SHD1024X32MCOL_EVEN_M8
****
.SUBCKT RA1SHD1024X32MCOL_ODD_M8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WP WP_0 WP_1 WP_2 WP_3
+  WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16
+  WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28
+  WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40
+  WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52
+  WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64
+  WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76
+  WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88
+  WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100
+  WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110
+  WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120
+  WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32MCOL_ODD_M8: 6420 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SHD1024X32FCBWM8
XI0_1 BWE BWEN D DPN DPU STUBDW STUBDW_ D_ GTP OE_ Q QI SP VSS VDD
+  RA1SHD1024X32IOX
XI0_2 DPN DPU STUBDR STUBDR_ STUBDW STUBDW_ GTP_0 SP VSS VDD RA1SHD1024X32SA8
XI0_3 A0 A0_ BL_ BL BL_2 BL__3 BL_6 BL__2 BL_3 BL__6 BL_0 BL__0 BL__1 BL_4
+  BL__5 BL_1 BL__4 BL_5 VSS VSS VSS VSS GTP_1 STUBDR STUBDR_ STUBDR_0
+  STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32MUX_CD_ODD
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11
+  WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23
+  WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35
+  WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47
+  WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59
+  WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71
+  WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83
+  WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95
+  WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106
+  WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116
+  WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 VSS
+  VDD RA1SHD1024X32BIT_COL
.ENDS RA1SHD1024X32MCOL_ODD_M8
****
.SUBCKT RA1SHD1024X32FCBWLE8 BWEN D Q VSS VDD
** RA1SHD1024X32FCBWLE8: 3 flat devices **
d1 VSS Q DN 0.3364P 2.32U
d2 VSS BWEN DN 0.3364P 2.32U
d3 VSS D DN 0.3364P 2.32U
.ENDS RA1SHD1024X32FCBWLE8
****
.SUBCKT RA1SHD1024X32MCOL_EVEN_LE8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WP WP_0 WP_1 WP_2 WP_3
+  WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16
+  WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28
+  WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40
+  WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52
+  WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64
+  WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76
+  WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88
+  WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100
+  WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110
+  WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120
+  WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32MCOL_EVEN_LE8: 6421 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SHD1024X32FCBWLE8
XI0_1 BWE BWEN D DPN DPU STUBDW_0 STUBDW__0 D_ GTP OE_ Q QI SP VSS VDD
+  RA1SHD1024X32IOX
XI0_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_0 SP VSS VDD
+  RA1SHD1024X32SA8
XI0_3 A0 A0_ BL_ BL BL_2 BL__3 BL_6 BL__2 BL_3 BL__6 BL_0 BL__0 BL__1 BL_4
+  BL__5 BL_1 BL__4 BL_5 VSS STUBDR_0 STUBDR__0 VSS VSS STUBDW_0 STUBDW__0 VSS
+  GTP_1 STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD1024X32MUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11
+  WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23
+  WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35
+  WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47
+  WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59
+  WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71
+  WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83
+  WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95
+  WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106
+  WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116
+  WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 VSS
+  VDD RA1SHD1024X32BIT_COL
.ENDS RA1SHD1024X32MCOL_EVEN_LE8
****
.SUBCKT RA1SHD1024X32WING_16_LEFT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42
+  BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54
+  BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66
+  BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78
+  BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90
+  BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102
+  BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112
+  BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122
+  BL_123 BL_124 BL_125 BL_126 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BWEN BWEN_0 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11
+  D_12 D_13 D_14 GTP GTP_0 GTP_1 OE_ Q Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8
+  Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW
+  STUBDW_ STUBDW_0 STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD
** RA1SHD1024X32WING_16_LEFT: 102722 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1 OE_ Q STUBDR_67 STUBDR__65
+  STUBDR_0 STUBDR__0 STUBDW_69 STUBDW__71 STUBDW_0 STUBDW__0 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76
+  WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88
+  WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100
+  WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110
+  WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120
+  WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32MCOL_ODD_RO8
XI10_0 A0 A0_ BL_63 BL__63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL__64
+  BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BWEN_0 D_7 GTP GTP_0 GTP_1 OE_
+  Q_7 STUBDR_3 STUBDR__1 STUBDR_0_11 STUBDR__0_9 STUBDW_5 STUBDW__7
+  STUBDW_0_13 STUBDW__0_15 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_RO8
XI11_0 A0 A0_ BL_78 BL__78 BL_77 BL_76 BL_75 BL_74 BL_73 BL_72 BL_71 BL__77
+  BL__76 BL__75 BL__74 BL__73 BL__72 BL__71 BWEN_0 D_8 GTP GTP_0 GTP_1 OE_
+  Q_8 STUBDR_3 STUBDR__1 STUBDR_0_19 STUBDR__0_17 STUBDW_5 STUBDW__7
+  STUBDW_0_21 STUBDW__0_23 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_M8
XI12_0 A0 A0_ BL_79 BL__79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BWEN_0 D_9 GTP GTP_0 GTP_1 OE_
+  Q_9 STUBDR_27 STUBDR__25 STUBDR_0_19 STUBDR__0_17 STUBDW_29 STUBDW__31
+  STUBDW_0_21 STUBDW__0_23 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_M8
XI13_0 A0 A0_ BL_94 BL__94 BL_93 BL_92 BL_91 BL_90 BL_89 BL_88 BL_87 BL__93
+  BL__92 BL__91 BL__90 BL__89 BL__88 BL__87 BWEN_0 D_10 GTP GTP_0 GTP_1 OE_
+  Q_10 STUBDR_27 STUBDR__25 STUBDR_0_35 STUBDR__0_33 STUBDW_29 STUBDW__31
+  STUBDW_0_37 STUBDW__0_39 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_M8
XI15_0 A0 A0_ BL_95 BL__95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BWEN_0 D_11 GTP GTP_0 GTP_1
+  OE_ Q_11 STUBDR_43 STUBDR__41 STUBDR_0_35 STUBDR__0_33 STUBDW_45 STUBDW__47
+  STUBDW_0_37 STUBDW__0_39 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_M8
XI16_0 A0 A0_ BL_110 BL__110 BL_109 BL_108 BL_107 BL_106 BL_105 BL_104 BL_103
+  BL__109 BL__108 BL__107 BL__106 BL__105 BL__104 BL__103 BWEN_0 D_12 GTP
+  GTP_0 GTP_1 OE_ Q_12 STUBDR_43 STUBDR__41 STUBDR_0_51 STUBDR__0_49
+  STUBDW_45 STUBDW__47 STUBDW_0_53 STUBDW__0_55 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD1024X32MCOL_EVEN_M8
XI17_0 A0 A0_ BL_111 BL__111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118
+  BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 BWEN_0 D_13 GTP
+  GTP_0 GTP_1 OE_ Q_13 STUBDR_59 STUBDR__57 STUBDR_0_51 STUBDR__0_49
+  STUBDW_61 STUBDW__63 STUBDW_0_53 STUBDW__0_55 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD1024X32MCOL_ODD_M8
XI18_0 A0 A0_ BL_126 BL__126 BL_125 BL_124 BL_123 BL_122 BL_121 BL_120 BL_119
+  BL__125 BL__124 BL__123 BL__122 BL__121 BL__120 BL__119 BWEN_0 D_14 GTP
+  GTP_0 GTP_1 OE_ Q_14 STUBDR_59 STUBDR__57 STUBDR STUBDR_ STUBDW_61
+  STUBDW__63 STUBDW STUBDW_ WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_LE8
XI1_0 A0 A0_ BL_14 BL__14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL_7 BL__13 BL__12
+  BL__11 BL__10 BL__9 BL__8 BL__7 BWEN D_0 GTP GTP_0 GTP_1 OE_ Q_0 STUBDR_67
+  STUBDR__65 STUBDR_0_75 STUBDR__0_73 STUBDW_69 STUBDW__71 STUBDW_0_77
+  STUBDW__0_79 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32MCOL_EVEN_M8
XI2_0 A0 A0_ BL_15 BL__15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BWEN D_1 GTP GTP_0 GTP_1 OE_ Q_1
+  STUBDR_83 STUBDR__81 STUBDR_0_75 STUBDR__0_73 STUBDW_85 STUBDW__87
+  STUBDW_0_77 STUBDW__0_79 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_M8
XI3_0 A0 A0_ BL_30 BL__30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL__29
+  BL__28 BL__27 BL__26 BL__25 BL__24 BL__23 BWEN D_2 GTP GTP_0 GTP_1 OE_ Q_2
+  STUBDR_83 STUBDR__81 STUBDR_0_91 STUBDR__0_89 STUBDW_85 STUBDW__87
+  STUBDW_0_93 STUBDW__0_95 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_M8
XI5_0 A0 A0_ BL_31 BL__31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL__32
+  BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BWEN D_3 GTP GTP_0 GTP_1 OE_ Q_3
+  STUBDR_99 STUBDR__97 STUBDR_0_91 STUBDR__0_89 STUBDW_101 STUBDW__103
+  STUBDW_0_93 STUBDW__0_95 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_M8
XI6_0 A0 A0_ BL_46 BL__46 BL_45 BL_44 BL_43 BL_42 BL_41 BL_40 BL_39 BL__45
+  BL__44 BL__43 BL__42 BL__41 BL__40 BL__39 BWEN D_4 GTP GTP_0 GTP_1 OE_ Q_4
+  STUBDR_99 STUBDR__97 STUBDR_0_107 STUBDR__0_105 STUBDW_101 STUBDW__103
+  STUBDW_0_109 STUBDW__0_111 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_M8
XI7_0 A0 A0_ BL_47 BL__47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BWEN D_5 GTP GTP_0 GTP_1 OE_ Q_5
+  STUBDR_115 STUBDR__113 STUBDR_0_107 STUBDR__0_105 STUBDW_117 STUBDW__119
+  STUBDW_0_109 STUBDW__0_111 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_M8
XI8_0 A0 A0_ BL_62 BL__62 BL_61 BL_60 BL_59 BL_58 BL_57 BL_56 BL_55 BL__61
+  BL__60 BL__59 BL__58 BL__57 BL__56 BL__55 BWEN D_6 GTP GTP_0 GTP_1 OE_ Q_6
+  STUBDR_115 STUBDR__113 STUBDR_0_11 STUBDR__0_9 STUBDW_117 STUBDW__119
+  STUBDW_0_13 STUBDW__0_15 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_LE8
.ENDS RA1SHD1024X32WING_16_LEFT
****
.SUBCKT RA1SHD1024X32HXP12 A0 ACONN0 AGTPB AGTPT AMX0 AY0 AY0_ BWEN OEI_ WEI
+  XP_0 XP_1 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32HXP12: 50 flat devices **
d7 VSS A0 DN 0.3364P 2.32U
d8 VSS BWEN DN 0.3364P 2.32U
m1 N24 N27 VDD VDD P L=0.18U W=8.16U
m10 AP0-APN1 AGTPT AP0-AIND1 VDD P L=0.18U W=10.66U
m11 N44 AGTPT VDD VDD P L=0.18U W=1.48U
m12 N44 AGTPT VSS VSS N L=0.18U W=0.94U
m13 AP0-AIN21 N24 VDD VDD P L=0.18U W=5.94U
m14 AP0-AIN21 N24 VSS VSS N L=0.18U W=2.87U
m15 N38 VSS VDD VDD P L=0.18U W=5.94U
m16 N38 VSS VSS VSS N L=0.18U W=2.87U
m17 N39 VSS VDD VDD P L=0.18U W=5.94U
m18 N39 VSS VSS VSS N L=0.18U W=2.87U
m19 N73 N39 VSS VSS N L=0.18U W=6.24U
m2 N24 N27 VSS VSS N L=0.18U W=4U
m20 N72 N38 N73 VSS N L=0.18U W=6.24U
m21 AP0-AIND1 AP0-AIN21 N72 VSS N L=0.18U W=6.24U
m22 AP0-AIND1 N39 VDD VDD P L=0.18U W=10.66U
m23 N71 N39 VSS VSS N L=0.18U W=6.24U
m24 AP0-AIND1 N38 VDD VDD P L=0.18U W=10.66U
m25 N70 N38 N71 VSS N L=0.18U W=6.24U
m26 AP0-AIND1 AP0-AIN21 VDD VDD P L=0.18U W=10.66U
m27 AP0-AIND1 AP0-AIN21 N70 VSS N L=0.18U W=6.24U
m28 AP0-APN0 N55 AP0-AIND0 VSS N L=0.18U W=6.24U
m29 AP0-APN0 AGTPB AP0-AIND0 VDD P L=0.18U W=10.66U
m3 N23 ACONN0 VDD VDD P L=0.18U W=8.16U
m30 N55 AGTPB VDD VDD P L=0.18U W=1.48U
m31 N55 AGTPB VSS VSS N L=0.18U W=0.94U
m32 AP0-AIN20 N23 VDD VDD P L=0.18U W=5.94U
m33 AP0-AIN20 N23 VSS VSS N L=0.18U W=2.87U
m34 N77 N39 VSS VSS N L=0.18U W=6.24U
m35 N76 N38 N77 VSS N L=0.18U W=6.24U
m36 AP0-AIND0 AP0-AIN20 N76 VSS N L=0.18U W=6.24U
m37 AP0-AIND0 N39 VDD VDD P L=0.18U W=10.66U
m38 N75 N39 VSS VSS N L=0.18U W=6.24U
m39 AP0-AIND0 N38 VDD VDD P L=0.18U W=10.66U
m4 N23 ACONN0 VSS VSS N L=0.18U W=4.02U
m40 N74 N38 N75 VSS N L=0.18U W=6.24U
m41 AP0-AIND0 AP0-AIN20 VDD VDD P L=0.18U W=10.66U
m42 AP0-AIND0 AP0-AIN20 N74 VSS N L=0.18U W=6.24U
m43 AP0-APN1 XP_0 VDD VDD P L=0.27U W=0.22U
m44 AP0-APN1 XP_0 VSS VSS N L=0.54U W=0.22U
m45 XP_0 AP0-APN1 VDD VDD P L=0.18U W=28.56U
m46 XP_0 AP0-APN1 VSS VSS N L=0.18U W=15.13U
m47 AP0-APN0 XP_1 VDD VDD P L=0.27U W=0.22U
m48 AP0-APN0 XP_1 VSS VSS N L=0.54U W=0.22U
m49 XP_1 AP0-APN0 VDD VDD P L=0.18U W=28.56U
m5 N27 ACONN0 VDD VDD P L=0.18U W=6.52U
m50 XP_1 AP0-APN0 VSS VSS N L=0.18U W=15.13U
m6 N27 ACONN0 VSS VSS N L=0.18U W=3.2U
m9 AP0-APN1 N44 AP0-AIND1 VSS N L=0.18U W=6.24U
.ENDS RA1SHD1024X32HXP12
****
.SUBCKT RA1SHD1024X32HXP12X A0 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32HXP12X: 50 flat devices **
XI0_0 A0 A0 AGTPB AGTPT VSS AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32HXP12
.ENDS RA1SHD1024X32HXP12X
****
.SUBCKT RA1SHD1024X32HXP38 A0 A1 A2 ACONN0 ACONN1 ACONN2 AGTPB AGTPT AMX0 AMX1
+  AMX2 AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32HXP38: 192 flat devices **
d175 VSS A2 DN 0.3364P 2.32U
d176 VSS BWEN DN 0.3364P 2.32U
d183 VSS A1 DN 0.3364P 2.32U
d184 VSS BWEN DN 0.3364P 2.32U
d191 VSS A0 DN 0.3364P 2.32U
d192 VSS BWEN DN 0.3364P 2.32U
m1 AP67-APN1 N54 AP67-AIND1 VSS N L=0.18U W=6.24U
m10 N49 AI2_ VSS VSS N L=0.18U W=2.87U
m100 AP23-AIND1 N132 VDD VDD P L=0.18U W=10.66U
m101 N164 N132 N165 VSS N L=0.18U W=6.24U
m102 AP23-AIND1 AP23-AIN21 VDD VDD P L=0.18U W=10.66U
m103 AP23-AIND1 AP23-AIN21 N164 VSS N L=0.18U W=6.24U
m104 AP23-APN0 N149 AP23-AIND0 VSS N L=0.18U W=6.24U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD P L=0.18U W=10.66U
m106 N149 AGTPB VDD VDD P L=0.18U W=1.48U
m107 N149 AGTPB VSS VSS N L=0.18U W=0.94U
m108 AP23-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m109 AP23-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m11 N83 N49 VSS VSS N L=0.18U W=6.24U
m110 N171 N133 VSS VSS N L=0.18U W=6.24U
m111 N170 N132 N171 VSS N L=0.18U W=6.24U
m112 AP23-AIND0 AP23-AIN20 N170 VSS N L=0.18U W=6.24U
m113 AP23-AIND0 N133 VDD VDD P L=0.18U W=10.66U
m114 N169 N133 VSS VSS N L=0.18U W=6.24U
m115 AP23-AIND0 N132 VDD VDD P L=0.18U W=10.66U
m116 N168 N132 N169 VSS N L=0.18U W=6.24U
m117 AP23-AIND0 AP23-AIN20 VDD VDD P L=0.18U W=10.66U
m118 AP23-AIND0 AP23-AIN20 N168 VSS N L=0.18U W=6.24U
m119 AP23-APN1 XP_3 VDD VDD P L=0.27U W=0.22U
m12 N82 N48 N83 VSS N L=0.18U W=6.24U
m120 AP23-APN1 XP_3 VSS VSS N L=0.54U W=0.22U
m121 XP_3 AP23-APN1 VDD VDD P L=0.18U W=28.56U
m122 XP_3 AP23-APN1 VSS VSS N L=0.18U W=15.13U
m123 AP23-APN0 XP_2 VDD VDD P L=0.27U W=0.22U
m124 AP23-APN0 XP_2 VSS VSS N L=0.54U W=0.22U
m125 XP_2 AP23-APN0 VDD VDD P L=0.18U W=28.56U
m126 XP_2 AP23-APN0 VSS VSS N L=0.18U W=15.13U
m127 AP01-APN1 N180 AP01-AIND1 VSS N L=0.18U W=6.24U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD P L=0.18U W=10.66U
m129 N180 AGTPT VDD VDD P L=0.18U W=1.48U
m13 AP67-AIND1 AP67-AIN21 N82 VSS N L=0.18U W=6.24U
m130 N180 AGTPT VSS VSS N L=0.18U W=0.94U
m131 AP01-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m132 AP01-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m133 N174 AI1 VDD VDD P L=0.18U W=5.94U
m134 N174 AI1 VSS VSS N L=0.18U W=2.87U
m135 N175 AI2 VDD VDD P L=0.18U W=5.94U
m136 N175 AI2 VSS VSS N L=0.18U W=2.87U
m137 N209 N175 VSS VSS N L=0.18U W=6.24U
m138 N208 N174 N209 VSS N L=0.18U W=6.24U
m139 AP01-AIND1 AP01-AIN21 N208 VSS N L=0.18U W=6.24U
m14 AP67-AIND1 N49 VDD VDD P L=0.18U W=10.66U
m140 AP01-AIND1 N175 VDD VDD P L=0.18U W=10.66U
m141 N207 N175 VSS VSS N L=0.18U W=6.24U
m142 AP01-AIND1 N174 VDD VDD P L=0.18U W=10.66U
m143 N206 N174 N207 VSS N L=0.18U W=6.24U
m144 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.18U W=10.66U
m145 AP01-AIND1 AP01-AIN21 N206 VSS N L=0.18U W=6.24U
m146 AP01-APN0 N191 AP01-AIND0 VSS N L=0.18U W=6.24U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD P L=0.18U W=10.66U
m148 N191 AGTPB VDD VDD P L=0.18U W=1.48U
m149 N191 AGTPB VSS VSS N L=0.18U W=0.94U
m15 N81 N49 VSS VSS N L=0.18U W=6.24U
m150 AP01-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m151 AP01-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m152 N213 N175 VSS VSS N L=0.18U W=6.24U
m153 N212 N174 N213 VSS N L=0.18U W=6.24U
m154 AP01-AIND0 AP01-AIN20 N212 VSS N L=0.18U W=6.24U
m155 AP01-AIND0 N175 VDD VDD P L=0.18U W=10.66U
m156 N211 N175 VSS VSS N L=0.18U W=6.24U
m157 AP01-AIND0 N174 VDD VDD P L=0.18U W=10.66U
m158 N210 N174 N211 VSS N L=0.18U W=6.24U
m159 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.18U W=10.66U
m16 AP67-AIND1 N48 VDD VDD P L=0.18U W=10.66U
m160 AP01-AIND0 AP01-AIN20 N210 VSS N L=0.18U W=6.24U
m161 AP01-APN1 XP_1 VDD VDD P L=0.27U W=0.22U
m162 AP01-APN1 XP_1 VSS VSS N L=0.54U W=0.22U
m163 XP_1 AP01-APN1 VDD VDD P L=0.18U W=28.56U
m164 XP_1 AP01-APN1 VSS VSS N L=0.18U W=15.13U
m165 AP01-APN0 XP_0 VDD VDD P L=0.27U W=0.22U
m166 AP01-APN0 XP_0 VSS VSS N L=0.54U W=0.22U
m167 XP_0 AP01-APN0 VDD VDD P L=0.18U W=28.56U
m168 XP_0 AP01-APN0 VSS VSS N L=0.18U W=15.13U
m169 AI2 N214 VDD VDD P L=0.18U W=8.16U
m17 N80 N48 N81 VSS N L=0.18U W=6.24U
m170 AI2 N214 VSS VSS N L=0.18U W=4U
m171 AI2_ ACONN2 VDD VDD P L=0.18U W=8.16U
m172 AI2_ ACONN2 VSS VSS N L=0.18U W=4.02U
m173 N214 ACONN2 VDD VDD P L=0.18U W=6.52U
m174 N214 ACONN2 VSS VSS N L=0.18U W=3.2U
m177 AI1 N223 VDD VDD P L=0.18U W=8.16U
m178 AI1 N223 VSS VSS N L=0.18U W=4U
m179 AI1_ ACONN1 VDD VDD P L=0.18U W=8.16U
m18 AP67-AIND1 AP67-AIN21 VDD VDD P L=0.18U W=10.66U
m180 AI1_ ACONN1 VSS VSS N L=0.18U W=4.02U
m181 N223 ACONN1 VDD VDD P L=0.18U W=6.52U
m182 N223 ACONN1 VSS VSS N L=0.18U W=3.2U
m185 AI0 N232 VDD VDD P L=0.18U W=8.16U
m186 AI0 N232 VSS VSS N L=0.18U W=4U
m187 AI0_ ACONN0 VDD VDD P L=0.18U W=8.16U
m188 AI0_ ACONN0 VSS VSS N L=0.18U W=4.02U
m189 N232 ACONN0 VDD VDD P L=0.18U W=6.52U
m19 AP67-AIND1 AP67-AIN21 N80 VSS N L=0.18U W=6.24U
m190 N232 ACONN0 VSS VSS N L=0.18U W=3.2U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD P L=0.18U W=10.66U
m20 AP67-APN0 N65 AP67-AIND0 VSS N L=0.18U W=6.24U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD P L=0.18U W=10.66U
m22 N65 AGTPB VDD VDD P L=0.18U W=1.48U
m23 N65 AGTPB VSS VSS N L=0.18U W=0.94U
m24 AP67-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m25 AP67-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m26 N87 N49 VSS VSS N L=0.18U W=6.24U
m27 N86 N48 N87 VSS N L=0.18U W=6.24U
m28 AP67-AIND0 AP67-AIN20 N86 VSS N L=0.18U W=6.24U
m29 AP67-AIND0 N49 VDD VDD P L=0.18U W=10.66U
m3 N54 AGTPT VDD VDD P L=0.18U W=1.48U
m30 N85 N49 VSS VSS N L=0.18U W=6.24U
m31 AP67-AIND0 N48 VDD VDD P L=0.18U W=10.66U
m32 N84 N48 N85 VSS N L=0.18U W=6.24U
m33 AP67-AIND0 AP67-AIN20 VDD VDD P L=0.18U W=10.66U
m34 AP67-AIND0 AP67-AIN20 N84 VSS N L=0.18U W=6.24U
m35 AP67-APN1 XP_7 VDD VDD P L=0.27U W=0.22U
m36 AP67-APN1 XP_7 VSS VSS N L=0.54U W=0.22U
m37 XP_7 AP67-APN1 VDD VDD P L=0.18U W=28.56U
m38 XP_7 AP67-APN1 VSS VSS N L=0.18U W=15.13U
m39 AP67-APN0 XP_6 VDD VDD P L=0.27U W=0.22U
m4 N54 AGTPT VSS VSS N L=0.18U W=0.94U
m40 AP67-APN0 XP_6 VSS VSS N L=0.54U W=0.22U
m41 XP_6 AP67-APN0 VDD VDD P L=0.18U W=28.56U
m42 XP_6 AP67-APN0 VSS VSS N L=0.18U W=15.13U
m43 AP45-APN1 N96 AP45-AIND1 VSS N L=0.18U W=6.24U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD P L=0.18U W=10.66U
m45 N96 AGTPT VDD VDD P L=0.18U W=1.48U
m46 N96 AGTPT VSS VSS N L=0.18U W=0.94U
m47 AP45-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m48 AP45-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m49 N90 AI1 VDD VDD P L=0.18U W=5.94U
m5 AP67-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m50 N90 AI1 VSS VSS N L=0.18U W=2.87U
m51 N91 AI2_ VDD VDD P L=0.18U W=5.94U
m52 N91 AI2_ VSS VSS N L=0.18U W=2.87U
m53 N125 N91 VSS VSS N L=0.18U W=6.24U
m54 N124 N90 N125 VSS N L=0.18U W=6.24U
m55 AP45-AIND1 AP45-AIN21 N124 VSS N L=0.18U W=6.24U
m56 AP45-AIND1 N91 VDD VDD P L=0.18U W=10.66U
m57 N123 N91 VSS VSS N L=0.18U W=6.24U
m58 AP45-AIND1 N90 VDD VDD P L=0.18U W=10.66U
m59 N122 N90 N123 VSS N L=0.18U W=6.24U
m6 AP67-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m60 AP45-AIND1 AP45-AIN21 VDD VDD P L=0.18U W=10.66U
m61 AP45-AIND1 AP45-AIN21 N122 VSS N L=0.18U W=6.24U
m62 AP45-APN0 N107 AP45-AIND0 VSS N L=0.18U W=6.24U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD P L=0.18U W=10.66U
m64 N107 AGTPB VDD VDD P L=0.18U W=1.48U
m65 N107 AGTPB VSS VSS N L=0.18U W=0.94U
m66 AP45-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m67 AP45-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m68 N129 N91 VSS VSS N L=0.18U W=6.24U
m69 N128 N90 N129 VSS N L=0.18U W=6.24U
m7 N48 AI1_ VDD VDD P L=0.18U W=5.94U
m70 AP45-AIND0 AP45-AIN20 N128 VSS N L=0.18U W=6.24U
m71 AP45-AIND0 N91 VDD VDD P L=0.18U W=10.66U
m72 N127 N91 VSS VSS N L=0.18U W=6.24U
m73 AP45-AIND0 N90 VDD VDD P L=0.18U W=10.66U
m74 N126 N90 N127 VSS N L=0.18U W=6.24U
m75 AP45-AIND0 AP45-AIN20 VDD VDD P L=0.18U W=10.66U
m76 AP45-AIND0 AP45-AIN20 N126 VSS N L=0.18U W=6.24U
m77 AP45-APN1 XP_5 VDD VDD P L=0.27U W=0.22U
m78 AP45-APN1 XP_5 VSS VSS N L=0.54U W=0.22U
m79 XP_5 AP45-APN1 VDD VDD P L=0.18U W=28.56U
m8 N48 AI1_ VSS VSS N L=0.18U W=2.87U
m80 XP_5 AP45-APN1 VSS VSS N L=0.18U W=15.13U
m81 AP45-APN0 XP_4 VDD VDD P L=0.27U W=0.22U
m82 AP45-APN0 XP_4 VSS VSS N L=0.54U W=0.22U
m83 XP_4 AP45-APN0 VDD VDD P L=0.18U W=28.56U
m84 XP_4 AP45-APN0 VSS VSS N L=0.18U W=15.13U
m85 AP23-APN1 N138 AP23-AIND1 VSS N L=0.18U W=6.24U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD P L=0.18U W=10.66U
m87 N138 AGTPT VDD VDD P L=0.18U W=1.48U
m88 N138 AGTPT VSS VSS N L=0.18U W=0.94U
m89 AP23-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m9 N49 AI2_ VDD VDD P L=0.18U W=5.94U
m90 AP23-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m91 N132 AI1_ VDD VDD P L=0.18U W=5.94U
m92 N132 AI1_ VSS VSS N L=0.18U W=2.87U
m93 N133 AI2 VDD VDD P L=0.18U W=5.94U
m94 N133 AI2 VSS VSS N L=0.18U W=2.87U
m95 N167 N133 VSS VSS N L=0.18U W=6.24U
m96 N166 N132 N167 VSS N L=0.18U W=6.24U
m97 AP23-AIND1 AP23-AIN21 N166 VSS N L=0.18U W=6.24U
m98 AP23-AIND1 N133 VDD VDD P L=0.18U W=10.66U
m99 N165 N133 VSS VSS N L=0.18U W=6.24U
.ENDS RA1SHD1024X32HXP38
****
.SUBCKT RA1SHD1024X32HXP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0
+  XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32HXP38X: 192 flat devices **
XI0_0 A0 A1 A2 A0 A1 A2 AGTPB AGTPT VSS VSS VSS AY0 AY0_ BWEN OEI_ WEI XP_0
+  XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD1024X32HXP38
.ENDS RA1SHD1024X32HXP38X
****
.SUBCKT RA1SHD1024X32X_PRE_DECODE A0 A0_0 A0_1 A1 A1_0 A2 A2_0 AGTPB AGTPT AY0
+  AY0_ BWEN OEI_ WEI XP_0 XP_0_0 XP_0_1 XP_1 XP_1_0 XP_1_1 XP_2 XP_2_0 XP_3
+  XP_3_0 XP_4 XP_4_0 XP_5 XP_5_0 XP_6 XP_6_0 XP_7 XP_7_0 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32X_PRE_DECODE: 434 flat devices **
XI0_0 A0 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32HXP12X
XI1_0 A0_0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_0 XP_1_0 XP_2 XP_3
+  XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32HXP38X
XI2_0 A0_1 A1_0 A2_0 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_1 XP_1_1 XP_2_0
+  XP_3_0 XP_4_0 XP_5_0 XP_6_0 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD1024X32HXP38X
.ENDS RA1SHD1024X32X_PRE_DECODE
****
.SUBCKT RA1SHD1024X32HYP24 A0 A1 ACONN0 ACONN1 AGTPB AGTPT AMX0 AMX1 AY0 AY0_
+  BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
** RA1SHD1024X32HYP24: 100 flat devices **
d15 VSS A1 DN 0.3364P 2.32U
d16 VSS BWEN DN 0.3364P 2.32U
d7 VSS A0 DN 0.3364P 2.32U
d8 VSS BWEN DN 0.3364P 2.32U
m1 AI0 N28 VDD VDD P L=0.18U W=8.16U
m10 AI1 N37 VSS VSS N L=0.18U W=4U
m100 YP0_3 AP_I6-APN0 VSS VSS N L=0.18U W=15.13U
m11 AI1_ ACONN1 VDD VDD P L=0.18U W=8.16U
m12 AI1_ ACONN1 VSS VSS N L=0.18U W=4.02U
m13 N37 ACONN1 VDD VDD P L=0.18U W=6.52U
m14 N37 ACONN1 VSS VSS N L=0.18U W=3.2U
m17 AP_I5-APN1 N54 AP_I5-AIND1 VSS N L=0.18U W=6.24U
m18 AP_I5-APN1 AGTPT AP_I5-AIND1 VDD P L=0.18U W=10.66U
m19 N54 AGTPT VDD VDD P L=0.18U W=1.48U
m2 AI0 N28 VSS VSS N L=0.18U W=4U
m20 N54 AGTPT VSS VSS N L=0.18U W=0.94U
m21 AP_I5-AIN21 AI0 VDD VDD P L=0.18U W=5.94U
m22 AP_I5-AIN21 AI0 VSS VSS N L=0.18U W=2.87U
m23 N48 AI1 VDD VDD P L=0.18U W=5.94U
m24 N48 AI1 VSS VSS N L=0.18U W=2.87U
m25 N49 VSS VDD VDD P L=0.18U W=5.94U
m26 N49 VSS VSS VSS N L=0.18U W=2.87U
m27 N83 N49 VSS VSS N L=0.18U W=6.24U
m28 N82 N48 N83 VSS N L=0.18U W=6.24U
m29 AP_I5-AIND1 AP_I5-AIN21 N82 VSS N L=0.18U W=6.24U
m3 AI0_ ACONN0 VDD VDD P L=0.18U W=8.16U
m30 AP_I5-AIND1 N49 VDD VDD P L=0.18U W=10.66U
m31 N81 N49 VSS VSS N L=0.18U W=6.24U
m32 AP_I5-AIND1 N48 VDD VDD P L=0.18U W=10.66U
m33 N80 N48 N81 VSS N L=0.18U W=6.24U
m34 AP_I5-AIND1 AP_I5-AIN21 VDD VDD P L=0.18U W=10.66U
m35 AP_I5-AIND1 AP_I5-AIN21 N80 VSS N L=0.18U W=6.24U
m36 AP_I5-APN0 N65 AP_I5-AIND0 VSS N L=0.18U W=6.24U
m37 AP_I5-APN0 AGTPB AP_I5-AIND0 VDD P L=0.18U W=10.66U
m38 N65 AGTPB VDD VDD P L=0.18U W=1.48U
m39 N65 AGTPB VSS VSS N L=0.18U W=0.94U
m4 AI0_ ACONN0 VSS VSS N L=0.18U W=4.02U
m40 AP_I5-AIN20 AI0_ VDD VDD P L=0.18U W=5.94U
m41 AP_I5-AIN20 AI0_ VSS VSS N L=0.18U W=2.87U
m42 N87 N49 VSS VSS N L=0.18U W=6.24U
m43 N86 N48 N87 VSS N L=0.18U W=6.24U
m44 AP_I5-AIND0 AP_I5-AIN20 N86 VSS N L=0.18U W=6.24U
m45 AP_I5-AIND0 N49 VDD VDD P L=0.18U W=10.66U
m46 N85 N49 VSS VSS N L=0.18U W=6.24U
m47 AP_I5-AIND0 N48 VDD VDD P L=0.18U W=10.66U
m48 N84 N48 N85 VSS N L=0.18U W=6.24U
m49 AP_I5-AIND0 AP_I5-AIN20 VDD VDD P L=0.18U W=10.66U
m5 N28 ACONN0 VDD VDD P L=0.18U W=6.52U
m50 AP_I5-AIND0 AP_I5-AIN20 N84 VSS N L=0.18U W=6.24U
m51 AP_I5-APN1 YP0_0 VDD VDD P L=0.27U W=0.22U
m52 AP_I5-APN1 YP0_0 VSS VSS N L=0.54U W=0.22U
m53 YP0_0 AP_I5-APN1 VDD VDD P L=0.18U W=28.56U
m54 YP0_0 AP_I5-APN1 VSS VSS N L=0.18U W=15.13U
m55 AP_I5-APN0 YP0_1 VDD VDD P L=0.27U W=0.22U
m56 AP_I5-APN0 YP0_1 VSS VSS N L=0.54U W=0.22U
m57 YP0_1 AP_I5-APN0 VDD VDD P L=0.18U W=28.56U
m58 YP0_1 AP_I5-APN0 VSS VSS N L=0.18U W=15.13U
m59 AP_I6-APN1 N96 AP_I6-AIND1 VSS N L=0.18U W=6.24U
m6 N28 ACONN0 VSS VSS N L=0.18U W=3.2U
m60 AP_I6-APN1 AGTPT AP_I6-AIND1 VDD P L=0.18U W=10.66U
m61 N96 AGTPT VDD VDD P L=0.18U W=1.48U
m62 N96 AGTPT VSS VSS N L=0.18U W=0.94U
m63 AP_I6-AIN21 AI0 VDD VDD P L=0.18U W=5.94U
m64 AP_I6-AIN21 AI0 VSS VSS N L=0.18U W=2.87U
m65 N90 AI1_ VDD VDD P L=0.18U W=5.94U
m66 N90 AI1_ VSS VSS N L=0.18U W=2.87U
m67 N91 VSS VDD VDD P L=0.18U W=5.94U
m68 N91 VSS VSS VSS N L=0.18U W=2.87U
m69 N125 N91 VSS VSS N L=0.18U W=6.24U
m70 N124 N90 N125 VSS N L=0.18U W=6.24U
m71 AP_I6-AIND1 AP_I6-AIN21 N124 VSS N L=0.18U W=6.24U
m72 AP_I6-AIND1 N91 VDD VDD P L=0.18U W=10.66U
m73 N123 N91 VSS VSS N L=0.18U W=6.24U
m74 AP_I6-AIND1 N90 VDD VDD P L=0.18U W=10.66U
m75 N122 N90 N123 VSS N L=0.18U W=6.24U
m76 AP_I6-AIND1 AP_I6-AIN21 VDD VDD P L=0.18U W=10.66U
m77 AP_I6-AIND1 AP_I6-AIN21 N122 VSS N L=0.18U W=6.24U
m78 AP_I6-APN0 N107 AP_I6-AIND0 VSS N L=0.18U W=6.24U
m79 AP_I6-APN0 AGTPB AP_I6-AIND0 VDD P L=0.18U W=10.66U
m80 N107 AGTPB VDD VDD P L=0.18U W=1.48U
m81 N107 AGTPB VSS VSS N L=0.18U W=0.94U
m82 AP_I6-AIN20 AI0_ VDD VDD P L=0.18U W=5.94U
m83 AP_I6-AIN20 AI0_ VSS VSS N L=0.18U W=2.87U
m84 N129 N91 VSS VSS N L=0.18U W=6.24U
m85 N128 N90 N129 VSS N L=0.18U W=6.24U
m86 AP_I6-AIND0 AP_I6-AIN20 N128 VSS N L=0.18U W=6.24U
m87 AP_I6-AIND0 N91 VDD VDD P L=0.18U W=10.66U
m88 N127 N91 VSS VSS N L=0.18U W=6.24U
m89 AP_I6-AIND0 N90 VDD VDD P L=0.18U W=10.66U
m9 AI1 N37 VDD VDD P L=0.18U W=8.16U
m90 N126 N90 N127 VSS N L=0.18U W=6.24U
m91 AP_I6-AIND0 AP_I6-AIN20 VDD VDD P L=0.18U W=10.66U
m92 AP_I6-AIND0 AP_I6-AIN20 N126 VSS N L=0.18U W=6.24U
m93 AP_I6-APN1 YP0_2 VDD VDD P L=0.27U W=0.22U
m94 AP_I6-APN1 YP0_2 VSS VSS N L=0.54U W=0.22U
m95 YP0_2 AP_I6-APN1 VDD VDD P L=0.18U W=28.56U
m96 YP0_2 AP_I6-APN1 VSS VSS N L=0.18U W=15.13U
m97 AP_I6-APN0 YP0_3 VDD VDD P L=0.27U W=0.22U
m98 AP_I6-APN0 YP0_3 VSS VSS N L=0.54U W=0.22U
m99 YP0_3 AP_I6-APN0 VDD VDD P L=0.18U W=28.56U
.ENDS RA1SHD1024X32HYP24
****
.SUBCKT RA1SHD1024X32HYP24X A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI YP0_0
+  YP0_1 YP0_2 YP0_3 VSS VDD
** RA1SHD1024X32HYP24X: 100 flat devices **
XI0_0 A0 A1 A0 A1 AGTPB AGTPT VSS VSS AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VDD RA1SHD1024X32HYP24
.ENDS RA1SHD1024X32HYP24X
****
.SUBCKT RA1SHD1024X32HYP12XR A0 ACONN0 AGTP AMX0 AY0 AY0_ BWEN CLK GSRCN GTPN
+  OEI_ RST WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32HYP12XR: 92 flat devices **
d7 VSS A0 DN 0.3364P 2.32U
d8 VSS BWEN DN 0.3364P 2.32U
m1 N24 N27 VDD VDD P L=0.18U W=8.16U
m10 AP0-APN1 AGTP AP0-AIND1 VDD P L=0.18U W=10.66U
m11 N44 AGTP VDD VDD P L=0.18U W=1.48U
m12 N44 AGTP VSS VSS N L=0.18U W=0.94U
m13 AP0-AIN21 N24 VDD VDD P L=0.18U W=5.94U
m14 AP0-AIN21 N24 VSS VSS N L=0.18U W=2.87U
m15 N38 VSS VDD VDD P L=0.18U W=5.94U
m16 N38 VSS VSS VSS N L=0.18U W=2.87U
m17 N39 VSS VDD VDD P L=0.18U W=5.94U
m18 N39 VSS VSS VSS N L=0.18U W=2.87U
m19 N73 N39 VSS VSS N L=0.18U W=6.24U
m2 N24 N27 VSS VSS N L=0.18U W=4U
m20 N72 N38 N73 VSS N L=0.18U W=6.24U
m21 AP0-AIND1 AP0-AIN21 N72 VSS N L=0.18U W=6.24U
m22 AP0-AIND1 N39 VDD VDD P L=0.18U W=10.66U
m23 N71 N39 VSS VSS N L=0.18U W=6.24U
m24 AP0-AIND1 N38 VDD VDD P L=0.18U W=10.66U
m25 N70 N38 N71 VSS N L=0.18U W=6.24U
m26 AP0-AIND1 AP0-AIN21 VDD VDD P L=0.18U W=10.66U
m27 AP0-AIND1 AP0-AIN21 N70 VSS N L=0.18U W=6.24U
m28 AP0-APN0 N55 AP0-AIND0 VSS N L=0.18U W=6.24U
m29 AP0-APN0 AGTP AP0-AIND0 VDD P L=0.18U W=10.66U
m3 N23 ACONN0 VDD VDD P L=0.18U W=8.16U
m30 N55 AGTP VDD VDD P L=0.18U W=1.48U
m31 N55 AGTP VSS VSS N L=0.18U W=0.94U
m32 AP0-AIN20 N23 VDD VDD P L=0.18U W=5.94U
m33 AP0-AIN20 N23 VSS VSS N L=0.18U W=2.87U
m34 N77 N39 VSS VSS N L=0.18U W=6.24U
m35 N76 N38 N77 VSS N L=0.18U W=6.24U
m36 AP0-AIND0 AP0-AIN20 N76 VSS N L=0.18U W=6.24U
m37 AP0-AIND0 N39 VDD VDD P L=0.18U W=10.66U
m38 N75 N39 VSS VSS N L=0.18U W=6.24U
m39 AP0-AIND0 N38 VDD VDD P L=0.18U W=10.66U
m4 N23 ACONN0 VSS VSS N L=0.18U W=4.02U
m40 N74 N38 N75 VSS N L=0.18U W=6.24U
m41 AP0-AIND0 AP0-AIN20 VDD VDD P L=0.18U W=10.66U
m42 AP0-AIND0 AP0-AIN20 N74 VSS N L=0.18U W=6.24U
m43 AP0-APN1 AY0_ VDD VDD P L=0.27U W=0.22U
m44 AP0-APN1 AY0_ VSS VSS N L=0.54U W=0.22U
m45 AY0_ AP0-APN1 VDD VDD P L=0.18U W=28.56U
m46 AY0_ AP0-APN1 VSS VSS N L=0.18U W=15.13U
m47 AP0-APN0 AY0 VDD VDD P L=0.27U W=0.22U
m48 AP0-APN0 AY0 VSS VSS N L=0.54U W=0.22U
m49 AY0 AP0-APN0 VDD VDD P L=0.18U W=28.56U
m5 N27 ACONN0 VDD VDD P L=0.18U W=6.52U
m50 AY0 AP0-APN0 VSS VSS N L=0.18U W=15.13U
m51 AP_I1-APN1 N86 AP_I1-AIND1 VSS N L=0.18U W=6.24U
m52 AP_I1-APN1 AGTP AP_I1-AIND1 VDD P L=0.18U W=10.66U
m53 N86 AGTP VDD VDD P L=0.18U W=1.48U
m54 N86 AGTP VSS VSS N L=0.18U W=0.94U
m55 AP_I1-AIN21 N24 VDD VDD P L=0.18U W=5.94U
m56 AP_I1-AIN21 N24 VSS VSS N L=0.18U W=2.87U
m57 N80 VSS VDD VDD P L=0.18U W=5.94U
m58 N80 VSS VSS VSS N L=0.18U W=2.87U
m59 N81 VSS VDD VDD P L=0.18U W=5.94U
m6 N27 ACONN0 VSS VSS N L=0.18U W=3.2U
m60 N81 VSS VSS VSS N L=0.18U W=2.87U
m61 N115 N81 VSS VSS N L=0.18U W=6.24U
m62 N114 N80 N115 VSS N L=0.18U W=6.24U
m63 AP_I1-AIND1 AP_I1-AIN21 N114 VSS N L=0.18U W=6.24U
m64 AP_I1-AIND1 N81 VDD VDD P L=0.18U W=10.66U
m65 N113 N81 VSS VSS N L=0.18U W=6.24U
m66 AP_I1-AIND1 N80 VDD VDD P L=0.18U W=10.66U
m67 N112 N80 N113 VSS N L=0.18U W=6.24U
m68 AP_I1-AIND1 AP_I1-AIN21 VDD VDD P L=0.18U W=10.66U
m69 AP_I1-AIND1 AP_I1-AIN21 N112 VSS N L=0.18U W=6.24U
m70 AP_I1-APN0 N97 AP_I1-AIND0 VSS N L=0.18U W=6.24U
m71 AP_I1-APN0 AGTP AP_I1-AIND0 VDD P L=0.18U W=10.66U
m72 N97 AGTP VDD VDD P L=0.18U W=1.48U
m73 N97 AGTP VSS VSS N L=0.18U W=0.94U
m74 AP_I1-AIN20 N23 VDD VDD P L=0.18U W=5.94U
m75 AP_I1-AIN20 N23 VSS VSS N L=0.18U W=2.87U
m76 N119 N81 VSS VSS N L=0.18U W=6.24U
m77 N118 N80 N119 VSS N L=0.18U W=6.24U
m78 AP_I1-AIND0 AP_I1-AIN20 N118 VSS N L=0.18U W=6.24U
m79 AP_I1-AIND0 N81 VDD VDD P L=0.18U W=10.66U
m80 N117 N81 VSS VSS N L=0.18U W=6.24U
m81 AP_I1-AIND0 N80 VDD VDD P L=0.18U W=10.66U
m82 N116 N80 N117 VSS N L=0.18U W=6.24U
m83 AP_I1-AIND0 AP_I1-AIN20 VDD VDD P L=0.18U W=10.66U
m84 AP_I1-AIND0 AP_I1-AIN20 N116 VSS N L=0.18U W=6.24U
m85 AP_I1-APN1 AY0_ VDD VDD P L=0.27U W=0.22U
m86 AP_I1-APN1 AY0_ VSS VSS N L=0.54U W=0.22U
m87 AY0_ AP_I1-APN1 VDD VDD P L=0.18U W=28.56U
m88 AY0_ AP_I1-APN1 VSS VSS N L=0.18U W=15.13U
m89 AP_I1-APN0 AY0 VDD VDD P L=0.27U W=0.22U
m9 AP0-APN1 N44 AP0-AIND1 VSS N L=0.18U W=6.24U
m90 AP_I1-APN0 AY0 VSS VSS N L=0.54U W=0.22U
m91 AY0 AP_I1-APN0 VDD VDD P L=0.18U W=28.56U
m92 AY0 AP_I1-APN0 VSS VSS N L=0.18U W=15.13U
.ENDS RA1SHD1024X32HYP12XR
****
.SUBCKT RA1SHD1024X32HYP12XRX A0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST
+  WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32HYP12XRX: 92 flat devices **
XI0_0 A0 A0 AGTP VSS AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32HYP12XR
.ENDS RA1SHD1024X32HYP12XRX
****
.SUBCKT RA1SHD1024X32Y_DECODE A0 A0_0 A1 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN
+  OEI_ RST WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
** RA1SHD1024X32Y_DECODE: 192 flat devices **
XI0_0 A0 A1 AGTP AGTP AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
+  RA1SHD1024X32HYP24X
XI1_0 A0_0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VSS VSS VSS VSS VDD RA1SHD1024X32HYP12XRX
.ENDS RA1SHD1024X32Y_DECODE
****
.SUBCKT RA1SHD1024X32HBF8 CEMX CEN CENI_ CEN_ CLK GSRCN GTP GTPN MBL OEI_ OEMX
+  OEN OENI_ OEN_ RST STOV STUBWE TMS WE WEI WEMX WEN WENI_ WEN_ VSS VDD
** RA1SHD1024X32HBF8: 91 flat devices **
d86 VSS WEN DN 0.3364P 2.32U
d87 VSS OEN DN 0.3364P 2.32U
d88 VSS CEN DN 0.3364P 2.32U
d89 VSS STOV DN 0.3364P 2.32U
d90 VSS CLK DN 0.3364P 2.32U
d91 VSS TMS DN 0.3364P 2.32U
m1 WE N44 VDD VDD P L=0.18U W=13.78U
m10 BF-CLKN CLK VSS VSS N L=0.36U W=1.44U
m11 N44 BF-TMS_ VDD VDD P L=0.18U W=6.12U
m12 N97 BF-TMS_ VSS VSS N L=0.18U W=4.59U
m13 N44 WENI_ VDD VDD P L=0.18U W=6.12U
m14 N44 WENI_ N97 VSS N L=0.18U W=4.59U
m15 BF-TMS_ TMS VDD VDD P L=0.18U W=2.95U
m16 BF-TMS_ TMS VSS VSS N L=0.18U W=1.52U
m17 OEI_ N57 VDD VDD P L=0.18U W=15.86U
m18 OEI_ N57 VSS VSS N L=0.18U W=8.16U
m19 N57 N60 VDD VDD P L=0.18U W=5.85U
m2 WE N44 VSS VSS N L=0.18U W=7.09U
m20 N57 N60 VSS VSS N L=0.18U W=3.01U
m21 N60 BF-TMS_ VDD VDD P L=0.18U W=2.27U
m22 N98 BF-TMS_ VSS VSS N L=0.18U W=2.22U
m23 N60 OENI_ VDD VDD P L=0.18U W=2.27U
m24 N60 OENI_ N98 VSS N L=0.18U W=2.22U
m25 N100 GTP VSS VSS N L=0.18U W=2.67U
m26 BF-RSRCN BF-CKSTOV N100 VSS N L=0.18U W=2.67U
m27 BF-RSRCN GTP VDD VDD P L=0.18U W=5.7U
m28 N99 GTP VSS VSS N L=0.18U W=2.67U
m29 BF-RSRCN BF-CKSTOV VDD VDD P L=0.18U W=5.7U
m3 BF-CENMML BF-CLKN N96 VDD P L=0.18U W=0.22U
m30 BF-RSRCN BF-CKSTOV N99 VSS N L=0.18U W=2.67U
m31 BF-RSTSRC BF-RSRCN VDD VDD P L=0.18U W=14.16U
m32 BF-RSTSRC BF-RSRCN VSS VSS N L=0.18U W=6.62U
m33 BF-CKSTOV STOV VDD VDD P L=0.18U W=2.68U
m34 N101 STOV VSS VSS N L=0.18U W=2.51U
m35 BF-CKSTOV CLK VDD VDD P L=0.18U W=2.68U
m36 BF-CKSTOV CLK N101 VSS N L=0.18U W=2.51U
m37 GTPN BF-GTPI N71 VSS N L=0.18U W=0.22U
m38 N37 N37 VDD VDD P L=0.18U W=0.22U
m39 GTPN BF-GTPI VDD VDD P L=0.18U W=0.22U
m4 N96 BF-CEL VDD VDD P L=0.18U W=0.22U
m40 N37 VDD VDD VDD P L=0.18U W=0.22U
m41 BF-GTPI GTPN VDD VDD P L=0.18U W=0.44U
m42 BF-GTPI GTPN VSS VSS N L=0.18U W=0.22U
m43 N71 N37 VSS VSS N L=0.18U W=0.22U
m44 N103 BF-CLKN VSS VSS N L=0.18U W=3.35U
m45 GSRCN BF-CEL N103 VSS N L=0.18U W=3.35U
m46 GSRCN BF-CLKN VDD VDD P L=0.18U W=5.72U
m47 N102 BF-CLKN VSS VSS N L=0.18U W=3.35U
m48 GSRCN BF-CEL VDD VDD P L=0.18U W=5.72U
m49 GSRCN BF-CEL N102 VSS N L=0.18U W=3.35U
m5 BF-CENMML CLK N95 VSS N L=0.18U W=0.22U
m50 N80 BF-CLKN VSS VSS N L=0.18U W=0.86U
m51 N82 CLK VDD VDD P L=0.18U W=2.17U
m52 BF-CENMML CENI_ N84 VDD P L=0.18U W=2.17U
m53 BF-CENMML CENI_ N80 VSS N L=0.18U W=0.85U
m54 N84 TMS N82 VDD P L=0.18U W=2.17U
m55 BF-CENMML TMS N80 VSS N L=0.18U W=0.85U
m56 RST BF-MBLN VDD VDD P L=0.18U W=3.3U
m57 RST BF-RSTSRC VDD VDD P L=0.18U W=22.49U
m58 BF-MBLN MBL VDD VDD P L=0.18U W=9.16U
m59 BF-MBLN MBL VSS VSS N L=0.18U W=3.06U
m6 N95 BF-CEL VSS VSS N L=0.18U W=0.22U
m60 WEN_ WEN VDD VDD P L=0.18U W=3.12U
m61 WEN_ WEN VSS VSS N L=0.18U W=1.53U
m62 OEN_ OEN VDD VDD P L=0.18U W=1.21U
m63 OEN_ OEN VSS VSS N L=0.18U W=0.59U
m64 CEN_ CEN VDD VDD P L=0.18U W=2.6U
m65 CEN_ CEN VSS VSS N L=0.18U W=1.28U
m66 RST BF-MBLN N113 VSS N L=0.18U W=2.74U
m67 N113 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m68 RST BF-MBLN N112 VSS N L=0.18U W=2.74U
m69 N112 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m7 BF-CEL BF-CENMML VDD VDD P L=0.18U W=2.63U
m70 RST BF-MBLN N111 VSS N L=0.18U W=2.74U
m71 N111 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m72 RST BF-MBLN N110 VSS N L=0.18U W=2.74U
m73 N110 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m74 RST BF-MBLN N109 VSS N L=0.18U W=2.74U
m75 N109 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m76 RST BF-MBLN N108 VSS N L=0.18U W=2.74U
m77 N108 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m78 RST BF-MBLN N107 VSS N L=0.18U W=2.74U
m79 N107 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m8 BF-CEL BF-CENMML VSS VSS N L=0.18U W=1.37U
m80 RST BF-MBLN N106 VSS N L=0.18U W=2.74U
m81 N106 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m82 RST BF-MBLN N105 VSS N L=0.18U W=2.74U
m83 N105 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m84 RST BF-MBLN N104 VSS N L=0.18U W=2.74U
m85 N104 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m9 BF-CLKN CLK VDD VDD P L=0.18U W=3.07U
.ENDS RA1SHD1024X32HBF8
****
.SUBCKT RA1SHD1024X32HBFX CEN CEN_ CLK GSRCN GTP GTPN MBL OEI_ OEN OEN_ RST
+  STUBWE WE WEI WEN_ VSS VDD
** RA1SHD1024X32HBFX: 91 flat devices **
XI0_0 VSS CEN CEN_ CEN_ CLK GSRCN GTP GTPN MBL OEI_ VSS OEN OEN_ OEN_ RST VSS
+  STUBWE VSS WE WEI VSS VSS WEN_ WEN_ VSS VDD RA1SHD1024X32HBF8
.ENDS RA1SHD1024X32HBFX
****
.SUBCKT RA1SHD1024X32CCMWP BL BL_ MWLB MWLT MWPB MWPT VSS VDD
** RA1SHD1024X32CCMWP: 12 flat devices **
m1 BL MWPT COREDT VSS N L=0.29U W=0.22U
m10 N18 VSS VDD VDD P L=0.19U W=0.22U
m11 COREDB VSS VSS VSS N L=0.18U W=0.25U
m12 COREDB_ VSS VSS VSS N L=0.18U W=0.25U
m2 BL_ MWPT COREDT_ VSS N L=0.29U W=0.22U
m3 BL MWPB COREDB VSS N L=0.29U W=0.22U
m4 BL_ MWPB COREDB_ VSS N L=0.29U W=0.22U
m5 COREDT VSS VSS VSS N L=0.18U W=0.25U
m6 COREDT_ VSS VSS VSS N L=0.18U W=0.25U
m7 N12 VSS VDD VDD P L=0.19U W=0.22U
m8 N14 VSS VDD VDD P L=0.19U W=0.22U
m9 N16 VSS VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD1024X32CCMWP
****
.SUBCKT RA1SHD1024X32CCMWG BL BL_ MWLB MWLT MWPB MWPT VSS VDD
** RA1SHD1024X32CCMWG: 12 flat devices **
m1 BL MWPT COREDT VSS N L=0.29U W=0.22U
m10 N18 VSS VDD VDD P L=0.19U W=0.22U
m11 COREDB VSS VSS VSS N L=0.18U W=0.25U
m12 COREDB_ VSS VSS VSS N L=0.18U W=0.25U
m2 BL_ MWPT COREDT_ VSS N L=0.29U W=0.22U
m3 BL MWPB COREDB VSS N L=0.29U W=0.22U
m4 BL_ MWPB COREDB_ VSS N L=0.29U W=0.22U
m5 COREDT VSS VSS VSS N L=0.18U W=0.25U
m6 COREDT_ VSS VSS VSS N L=0.18U W=0.25U
m7 N12 VSS VDD VDD P L=0.19U W=0.22U
m8 N14 VSS VDD VDD P L=0.19U W=0.22U
m9 N16 VSS VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD1024X32CCMWG
****
.SUBCKT RA1SHD1024X32FLMWG BL0 BL0_ BL1 BL1_ MWL WP0 WP1 WP2 WP3 VSS VDD
** RA1SHD1024X32FLMWG: 24 flat devices **
m1 BL0 WP1 N12 VSS N L=0.29U W=0.22U
m10 N22 VSS VDD VDD P L=0.19U W=0.22U
m11 N14 VSS VSS VSS N L=0.18U W=0.25U
m12 N15 VSS VSS VSS N L=0.18U W=0.25U
m13 BL1 WP3 N24 VSS N L=0.29U W=0.22U
m14 BL1_ WP3 N25 VSS N L=0.29U W=0.22U
m15 BL1 WP2 N26 VSS N L=0.29U W=0.22U
m16 BL1_ WP2 N27 VSS N L=0.29U W=0.22U
m17 N24 VSS VSS VSS N L=0.18U W=0.25U
m18 N25 VSS VSS VSS N L=0.18U W=0.25U
m19 N28 VSS VDD VDD P L=0.19U W=0.22U
m2 BL0_ WP3 N13 VSS N L=0.29U W=0.22U
m20 N30 VSS VDD VDD P L=0.19U W=0.22U
m21 N32 VSS VDD VDD P L=0.19U W=0.22U
m22 N34 VSS VDD VDD P L=0.19U W=0.22U
m23 N26 VSS VSS VSS N L=0.18U W=0.25U
m24 N27 VSS VSS VSS N L=0.18U W=0.25U
m3 BL0 WP0 N14 VSS N L=0.29U W=0.22U
m4 BL0_ WP2 N15 VSS N L=0.29U W=0.22U
m5 N12 VSS VSS VSS N L=0.18U W=0.25U
m6 N13 VSS VSS VSS N L=0.18U W=0.25U
m7 N16 VSS VDD VDD P L=0.19U W=0.22U
m8 N18 VSS VDD VDD P L=0.19U W=0.22U
m9 N20 VSS VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD1024X32FLMWG
****
.SUBCKT RA1SHD1024X32MODEL_ROW_16 BL BL0 BL0_ BL1 BL1_ BL_ BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16
+  BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28
+  BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40
+  BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52
+  BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64
+  BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76
+  BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88
+  BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100
+  BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110
+  BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120
+  BL_121 BL_122 BL_123 BL_124 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 MWLB WL VSS
+  VDD
** RA1SHD1024X32MODEL_ROW_16: 2304 flat devices **
XI0_0 BL BL_ MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI0_2 BL BL_ WL WL VSS VDD RA1SHD1024X32CCG
XI100_0 BL_94 BL__94 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI100_2 BL_94 BL__94 WL WL VSS VDD RA1SHD1024X32CCP
XI101_0 BL_95 BL__95 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI101_2 BL_95 BL__95 WL WL VSS VDD RA1SHD1024X32CCP
XI102_0 BL_96 BL__96 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI102_2 BL_96 BL__96 WL WL VSS VDD RA1SHD1024X32CCG
XI103_0 BL_97 BL__97 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI103_2 BL_97 BL__97 WL WL VSS VDD RA1SHD1024X32CCG
XI104_0 BL_98 BL__98 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI104_2 BL_98 BL__98 WL WL VSS VDD RA1SHD1024X32CCP
XI105_0 BL_99 BL__99 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI105_2 BL_99 BL__99 WL WL VSS VDD RA1SHD1024X32CCP
XI106_0 BL_100 BL__100 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI106_2 BL_100 BL__100 WL WL VSS VDD RA1SHD1024X32CCG
XI107_0 BL_101 BL__101 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI107_2 BL_101 BL__101 WL WL VSS VDD RA1SHD1024X32CCG
XI108_0 BL_102 BL__102 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI108_2 BL_102 BL__102 WL WL VSS VDD RA1SHD1024X32CCP
XI109_0 BL_103 BL__103 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI109_2 BL_103 BL__103 WL WL VSS VDD RA1SHD1024X32CCP
XI10_0 BL_9 BL__9 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI10_2 BL_9 BL__9 WL WL VSS VDD RA1SHD1024X32CCP
XI110_0 BL_104 BL__104 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI110_2 BL_104 BL__104 WL WL VSS VDD RA1SHD1024X32CCG
XI111_0 BL_105 BL__105 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI111_2 BL_105 BL__105 WL WL VSS VDD RA1SHD1024X32CCG
XI112_0 BL_106 BL__106 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI112_2 BL_106 BL__106 WL WL VSS VDD RA1SHD1024X32CCP
XI113_0 BL_107 BL__107 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI113_2 BL_107 BL__107 WL WL VSS VDD RA1SHD1024X32CCP
XI114_0 BL_108 BL__108 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI114_2 BL_108 BL__108 WL WL VSS VDD RA1SHD1024X32CCG
XI115_0 BL_109 BL__109 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI115_2 BL_109 BL__109 WL WL VSS VDD RA1SHD1024X32CCG
XI116_0 BL_110 BL__110 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI116_2 BL_110 BL__110 WL WL VSS VDD RA1SHD1024X32CCP
XI117_0 BL_111 BL__111 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI117_2 BL_111 BL__111 WL WL VSS VDD RA1SHD1024X32CCP
XI118_0 BL_112 BL__112 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI118_2 BL_112 BL__112 WL WL VSS VDD RA1SHD1024X32CCG
XI119_0 BL_113 BL__113 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI119_2 BL_113 BL__113 WL WL VSS VDD RA1SHD1024X32CCG
XI11_0 BL_10 BL__10 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI11_2 BL_10 BL__10 WL WL VSS VDD RA1SHD1024X32CCG
XI120_0 BL_114 BL__114 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI120_2 BL_114 BL__114 WL WL VSS VDD RA1SHD1024X32CCP
XI121_0 BL_115 BL__115 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI121_2 BL_115 BL__115 WL WL VSS VDD RA1SHD1024X32CCP
XI122_0 BL_116 BL__116 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI122_2 BL_116 BL__116 WL WL VSS VDD RA1SHD1024X32CCG
XI123_0 BL_117 BL__117 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI123_2 BL_117 BL__117 WL WL VSS VDD RA1SHD1024X32CCG
XI124_0 BL_118 BL__118 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI124_2 BL_118 BL__118 WL WL VSS VDD RA1SHD1024X32CCP
XI125_0 BL_119 BL__119 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI125_2 BL_119 BL__119 WL WL VSS VDD RA1SHD1024X32CCP
XI126_0 BL_120 BL__120 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI126_2 BL_120 BL__120 WL WL VSS VDD RA1SHD1024X32CCG
XI127_0 BL_121 BL__121 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI127_2 BL_121 BL__121 WL WL VSS VDD RA1SHD1024X32CCG
XI128_0 BL_122 BL__122 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI128_2 BL_122 BL__122 WL WL VSS VDD RA1SHD1024X32CCP
XI129_0 BL_123 BL__123 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI129_2 BL_123 BL__123 WL WL VSS VDD RA1SHD1024X32CCP
XI12_0 BL_11 BL__11 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI12_2 BL_11 BL__11 WL WL VSS VDD RA1SHD1024X32CCG
XI130_0 BL_124 BL__124 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI130_2 BL_124 BL__124 WL WL VSS VDD RA1SHD1024X32CCG
XI13_0 BL_12 BL__12 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI13_2 BL_12 BL__12 WL WL VSS VDD RA1SHD1024X32CCP
XI14_0 BL_13 BL__13 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI14_2 BL_13 BL__13 WL WL VSS VDD RA1SHD1024X32CCP
XI15_0 BL_14 BL__14 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI15_2 BL_14 BL__14 WL WL VSS VDD RA1SHD1024X32CCG
XI16_0 BL_15 BL__15 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI16_2 BL_15 BL__15 WL WL VSS VDD RA1SHD1024X32CCG
XI17_0 BL_16 BL__16 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI17_2 BL_16 BL__16 WL WL VSS VDD RA1SHD1024X32CCP
XI18_0 BL_17 BL__17 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI18_2 BL_17 BL__17 WL WL VSS VDD RA1SHD1024X32CCP
XI19_0 BL_18 BL__18 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI19_2 BL_18 BL__18 WL WL VSS VDD RA1SHD1024X32CCG
XI1_0 BL_0 BL__0 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI1_2 BL_0 BL__0 WL WL VSS VDD RA1SHD1024X32CCP
XI20_0 BL_19 BL__19 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI20_2 BL_19 BL__19 WL WL VSS VDD RA1SHD1024X32CCG
XI21_0 BL_20 BL__20 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI21_2 BL_20 BL__20 WL WL VSS VDD RA1SHD1024X32CCP
XI22_0 BL_21 BL__21 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI22_2 BL_21 BL__21 WL WL VSS VDD RA1SHD1024X32CCP
XI23_0 BL_22 BL__22 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI23_2 BL_22 BL__22 WL WL VSS VDD RA1SHD1024X32CCG
XI24_0 BL_23 BL__23 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI24_2 BL_23 BL__23 WL WL VSS VDD RA1SHD1024X32CCG
XI25_0 BL_24 BL__24 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI25_2 BL_24 BL__24 WL WL VSS VDD RA1SHD1024X32CCP
XI26_0 BL_25 BL__25 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI26_2 BL_25 BL__25 WL WL VSS VDD RA1SHD1024X32CCP
XI27_0 BL_26 BL__26 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI27_2 BL_26 BL__26 WL WL VSS VDD RA1SHD1024X32CCG
XI28_0 BL_27 BL__27 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI28_2 BL_27 BL__27 WL WL VSS VDD RA1SHD1024X32CCG
XI29_0 BL_28 BL__28 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI29_2 BL_28 BL__28 WL WL VSS VDD RA1SHD1024X32CCP
XI2_0 BL_1 BL__1 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI2_2 BL_1 BL__1 WL WL VSS VDD RA1SHD1024X32CCP
XI30_0 BL_29 BL__29 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI30_2 BL_29 BL__29 WL WL VSS VDD RA1SHD1024X32CCP
XI31_0 BL_30 BL__30 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI31_2 BL_30 BL__30 WL WL VSS VDD RA1SHD1024X32CCG
XI33_0 BL_31 BL__31 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI33_2 BL_31 BL__31 WL WL VSS VDD RA1SHD1024X32CCG
XI34_0 BL_32 BL__32 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI34_2 BL_32 BL__32 WL WL VSS VDD RA1SHD1024X32CCP
XI35_0 BL_33 BL__33 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI35_2 BL_33 BL__33 WL WL VSS VDD RA1SHD1024X32CCP
XI36_0 BL_34 BL__34 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI36_2 BL_34 BL__34 WL WL VSS VDD RA1SHD1024X32CCG
XI37_0 BL_35 BL__35 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI37_2 BL_35 BL__35 WL WL VSS VDD RA1SHD1024X32CCG
XI38_0 BL_36 BL__36 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI38_2 BL_36 BL__36 WL WL VSS VDD RA1SHD1024X32CCP
XI39_0 BL_37 BL__37 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI39_2 BL_37 BL__37 WL WL VSS VDD RA1SHD1024X32CCP
XI3_0 BL_2 BL__2 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI3_2 BL_2 BL__2 WL WL VSS VDD RA1SHD1024X32CCG
XI40_0 BL_38 BL__38 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI40_2 BL_38 BL__38 WL WL VSS VDD RA1SHD1024X32CCG
XI41_0 BL_39 BL__39 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI41_2 BL_39 BL__39 WL WL VSS VDD RA1SHD1024X32CCG
XI42_0 BL_40 BL__40 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI42_2 BL_40 BL__40 WL WL VSS VDD RA1SHD1024X32CCP
XI43_0 BL_41 BL__41 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI43_2 BL_41 BL__41 WL WL VSS VDD RA1SHD1024X32CCP
XI44_0 BL_42 BL__42 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI44_2 BL_42 BL__42 WL WL VSS VDD RA1SHD1024X32CCG
XI45_0 BL_43 BL__43 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI45_2 BL_43 BL__43 WL WL VSS VDD RA1SHD1024X32CCG
XI46_0 BL_44 BL__44 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI46_2 BL_44 BL__44 WL WL VSS VDD RA1SHD1024X32CCP
XI47_0 BL_45 BL__45 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI47_2 BL_45 BL__45 WL WL VSS VDD RA1SHD1024X32CCP
XI48_0 BL_46 BL__46 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI48_2 BL_46 BL__46 WL WL VSS VDD RA1SHD1024X32CCG
XI49_0 BL_47 BL__47 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI49_2 BL_47 BL__47 WL WL VSS VDD RA1SHD1024X32CCG
XI4_0 BL_3 BL__3 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI4_2 BL_3 BL__3 WL WL VSS VDD RA1SHD1024X32CCG
XI50_0 BL_48 BL__48 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI50_2 BL_48 BL__48 WL WL VSS VDD RA1SHD1024X32CCP
XI51_0 BL_49 BL__49 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI51_2 BL_49 BL__49 WL WL VSS VDD RA1SHD1024X32CCP
XI52_0 BL_50 BL__50 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI52_2 BL_50 BL__50 WL WL VSS VDD RA1SHD1024X32CCG
XI53_0 BL_51 BL__51 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI53_2 BL_51 BL__51 WL WL VSS VDD RA1SHD1024X32CCG
XI54_0 BL_52 BL__52 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI54_2 BL_52 BL__52 WL WL VSS VDD RA1SHD1024X32CCP
XI55_0 BL_53 BL__53 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI55_2 BL_53 BL__53 WL WL VSS VDD RA1SHD1024X32CCP
XI56_0 BL_54 BL__54 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI56_2 BL_54 BL__54 WL WL VSS VDD RA1SHD1024X32CCG
XI57_0 BL_55 BL__55 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI57_2 BL_55 BL__55 WL WL VSS VDD RA1SHD1024X32CCG
XI58_0 BL_56 BL__56 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI58_2 BL_56 BL__56 WL WL VSS VDD RA1SHD1024X32CCP
XI59_0 BL_57 BL__57 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI59_2 BL_57 BL__57 WL WL VSS VDD RA1SHD1024X32CCP
XI5_0 BL_4 BL__4 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI5_2 BL_4 BL__4 WL WL VSS VDD RA1SHD1024X32CCP
XI60_0 BL_58 BL__58 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI60_2 BL_58 BL__58 WL WL VSS VDD RA1SHD1024X32CCG
XI61_0 BL_59 BL__59 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI61_2 BL_59 BL__59 WL WL VSS VDD RA1SHD1024X32CCG
XI62_0 BL_60 BL__60 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI62_2 BL_60 BL__60 WL WL VSS VDD RA1SHD1024X32CCP
XI63_0 BL_61 BL__61 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI63_2 BL_61 BL__61 WL WL VSS VDD RA1SHD1024X32CCP
XI64_0 BL_62 BL__62 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI64_2 BL_62 BL__62 WL WL VSS VDD RA1SHD1024X32CCG
XI66_0 BL0 BL0_ BL1 BL1_ MWLB MWLB MWLB VSS VSS VSS VDD RA1SHD1024X32FLMWG
XI66_2 BL0 BL0_ WL WL VSS VDD RA1SHD1024X32CCG
XI67_2 BL1 BL1_ WL WL VSS VDD RA1SHD1024X32CCP
XI68_0 BL_63 BL__63 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI68_2 BL_63 BL__63 WL WL VSS VDD RA1SHD1024X32CCP
XI69_0 BL_64 BL__64 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI69_2 BL_64 BL__64 WL WL VSS VDD RA1SHD1024X32CCG
XI6_0 BL_5 BL__5 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI6_2 BL_5 BL__5 WL WL VSS VDD RA1SHD1024X32CCP
XI70_0 BL_65 BL__65 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI70_2 BL_65 BL__65 WL WL VSS VDD RA1SHD1024X32CCG
XI71_0 BL_66 BL__66 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI71_2 BL_66 BL__66 WL WL VSS VDD RA1SHD1024X32CCP
XI72_0 BL_67 BL__67 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI72_2 BL_67 BL__67 WL WL VSS VDD RA1SHD1024X32CCP
XI73_0 BL_68 BL__68 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI73_2 BL_68 BL__68 WL WL VSS VDD RA1SHD1024X32CCG
XI74_0 BL_69 BL__69 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI74_2 BL_69 BL__69 WL WL VSS VDD RA1SHD1024X32CCG
XI75_0 BL_70 BL__70 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI75_2 BL_70 BL__70 WL WL VSS VDD RA1SHD1024X32CCP
XI76_0 BL_71 BL__71 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI76_2 BL_71 BL__71 WL WL VSS VDD RA1SHD1024X32CCP
XI77_0 BL_72 BL__72 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI77_2 BL_72 BL__72 WL WL VSS VDD RA1SHD1024X32CCG
XI78_0 BL_73 BL__73 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI78_2 BL_73 BL__73 WL WL VSS VDD RA1SHD1024X32CCG
XI79_0 BL_74 BL__74 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI79_2 BL_74 BL__74 WL WL VSS VDD RA1SHD1024X32CCP
XI7_0 BL_6 BL__6 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI7_2 BL_6 BL__6 WL WL VSS VDD RA1SHD1024X32CCG
XI80_0 BL_75 BL__75 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI80_2 BL_75 BL__75 WL WL VSS VDD RA1SHD1024X32CCP
XI81_0 BL_76 BL__76 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI81_2 BL_76 BL__76 WL WL VSS VDD RA1SHD1024X32CCG
XI82_0 BL_77 BL__77 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI82_2 BL_77 BL__77 WL WL VSS VDD RA1SHD1024X32CCG
XI83_0 BL_78 BL__78 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI83_2 BL_78 BL__78 WL WL VSS VDD RA1SHD1024X32CCP
XI84_0 BL_79 BL__79 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI84_2 BL_79 BL__79 WL WL VSS VDD RA1SHD1024X32CCP
XI85_0 BL_80 BL__80 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI85_2 BL_80 BL__80 WL WL VSS VDD RA1SHD1024X32CCG
XI86_0 BL_81 BL__81 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI86_2 BL_81 BL__81 WL WL VSS VDD RA1SHD1024X32CCG
XI87_0 BL_82 BL__82 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI87_2 BL_82 BL__82 WL WL VSS VDD RA1SHD1024X32CCP
XI88_0 BL_83 BL__83 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI88_2 BL_83 BL__83 WL WL VSS VDD RA1SHD1024X32CCP
XI89_0 BL_84 BL__84 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI89_2 BL_84 BL__84 WL WL VSS VDD RA1SHD1024X32CCG
XI8_0 BL_7 BL__7 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWG
XI8_2 BL_7 BL__7 WL WL VSS VDD RA1SHD1024X32CCG
XI90_0 BL_85 BL__85 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI90_2 BL_85 BL__85 WL WL VSS VDD RA1SHD1024X32CCG
XI91_0 BL_86 BL__86 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI91_2 BL_86 BL__86 WL WL VSS VDD RA1SHD1024X32CCP
XI92_0 BL_87 BL__87 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI92_2 BL_87 BL__87 WL WL VSS VDD RA1SHD1024X32CCP
XI93_0 BL_88 BL__88 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI93_2 BL_88 BL__88 WL WL VSS VDD RA1SHD1024X32CCG
XI94_0 BL_89 BL__89 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI94_2 BL_89 BL__89 WL WL VSS VDD RA1SHD1024X32CCG
XI95_0 BL_90 BL__90 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI95_2 BL_90 BL__90 WL WL VSS VDD RA1SHD1024X32CCP
XI96_0 BL_91 BL__91 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWP
XI96_2 BL_91 BL__91 WL WL VSS VDD RA1SHD1024X32CCP
XI97_0 BL_92 BL__92 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI97_2 BL_92 BL__92 WL WL VSS VDD RA1SHD1024X32CCG
XI99_0 BL_93 BL__93 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CCMWG
XI99_2 BL_93 BL__93 WL WL VSS VDD RA1SHD1024X32CCG
XI9_0 BL_8 BL__8 MWLB MWLB MWLB MWLB VSS VDD RA1SHD1024X32CCMWP
XI9_2 BL_8 BL__8 WL WL VSS VDD RA1SHD1024X32CCP
.ENDS RA1SHD1024X32MODEL_ROW_16
****
.SUBCKT RA1SHD1024X32WD G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD1024X32WD: 30 flat devices **
m1 N25 RSWN0 GTP VDD P L=0.18U W=2.08U
m10 WL0 WL0_EN_ VSS VSS N L=0.18U W=15.71U
m11 N24 RSWN1 GTP VDD P L=0.18U W=2.08U
m12 N24 WLI1 GTP VSS N L=0.18U W=2.08U
m13 N33 G0 VSS VSS N L=0.18U W=1.73U
m14 N34 G1 N33 VSS N L=0.18U W=1.73U
m15 RSWN1 G2_W1 N34 VSS N L=0.18U W=1.73U
m16 RSWN1 G0 VDD VDD P L=0.18U W=1.35U
m17 RSWN1 G2_W1 VDD VDD P L=0.18U W=1.35U
m18 RSWN1 G1 VDD VDD P L=0.18U W=1.35U
m19 WL1 WL1_EN_ VDD VDD P L=0.18U W=30.96U
m2 N25 WLI0 GTP VSS N L=0.18U W=2.08U
m20 WL1 WL1_EN_ VSS VSS N L=0.18U W=15.71U
m21 WLI1 RSWN1 VDD VDD P L=0.18U W=0.61U
m22 WLI1 RSWN1 VSS VSS N L=0.18U W=0.29U
m23 WLI0 RSWN0 VDD VDD P L=0.18U W=0.61U
m24 WLI0 RSWN0 VSS VSS N L=0.18U W=0.29U
m25 N24 RSWN1 VSS VSS N L=0.18U W=2.08U
m26 N25 RSWN0 VSS VSS N L=0.18U W=2.08U
m27 WL1_EN_ N24 VDD VDD P L=0.18U W=14.22U
m28 WL1_EN_ N24 VSS VSS N L=0.18U W=6.66U
m29 WL0_EN_ N25 VDD VDD P L=0.18U W=14.22U
m3 N26 G0 VSS VSS N L=0.18U W=1.73U
m30 WL0_EN_ N25 VSS VSS N L=0.18U W=6.66U
m4 N27 G1 N26 VSS N L=0.18U W=1.73U
m5 RSWN0 G2_W0 N27 VSS N L=0.18U W=1.73U
m6 RSWN0 G0 VDD VDD P L=0.18U W=1.35U
m7 RSWN0 G2_W0 VDD VDD P L=0.18U W=1.35U
m8 RSWN0 G1 VDD VDD P L=0.18U W=1.35U
m9 WL0 WL0_EN_ VDD VDD P L=0.18U W=30.96U
.ENDS RA1SHD1024X32WD
****
.SUBCKT RA1SHD1024X32WD1 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD1024X32WD1: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD1024X32WD
.ENDS RA1SHD1024X32WD1
****
.SUBCKT RA1SHD1024X32ROW_FILLER1 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP0_2
+  XP1 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD
** RA1SHD1024X32ROW_FILLER1: 30 flat devices **
XI5_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD1024X32WD1
.ENDS RA1SHD1024X32ROW_FILLER1
****
.SUBCKT RA1SHD1024X32WD3 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD1024X32WD3: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD1024X32WD
.ENDS RA1SHD1024X32WD3
****
.SUBCKT RA1SHD1024X32ROW_FILLER3 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP0_2
+  XP1 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD
** RA1SHD1024X32ROW_FILLER3: 30 flat devices **
XI5_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD1024X32WD3
.ENDS RA1SHD1024X32ROW_FILLER3
****
.SUBCKT RA1SHD1024X32WD2 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD1024X32WD2: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD1024X32WD
.ENDS RA1SHD1024X32WD2
****
.SUBCKT RA1SHD1024X32ROW_FILLER2 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP0_2
+  XP1 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD
** RA1SHD1024X32ROW_FILLER2: 30 flat devices **
XI5_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD1024X32WD2
.ENDS RA1SHD1024X32ROW_FILLER2
****
.SUBCKT RA1SHD1024X32WD0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD1024X32WD0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD1024X32WD
.ENDS RA1SHD1024X32WD0
****
.SUBCKT RA1SHD1024X32ROW_8 G0 G1 G1B GTP WL0 WL1 XP0 XP0F XP0F_0 XP0F_1 XP0F_2
+  XP1 XP1F XP1F_0 XP1F_1 XP1F_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD
** RA1SHD1024X32ROW_8: 30 flat devices **
XI5_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD1024X32WD0
.ENDS RA1SHD1024X32ROW_8
****
.SUBCKT RA1SHD1024X32MWD GTP MBL MBL_ MWL XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD1024X32MWD: 9 flat devices **
m1 MWL N15 VDD VDD P L=0.18U W=30.96U
m2 MWL N15 VSS VSS N L=0.18U W=15.71U
m3 N15 N18 VDD VDD P L=0.18U W=16.51U
m4 N15 N18 VSS VSS N L=0.18U W=7.73U
m5 MBL GTP VDD VDD P L=0.18U W=15.35U
m6 MBL_ GTP VDD VDD P L=0.18U W=15.35U
m7 MBL GTP MBL_ VDD P L=0.18U W=15.35U
m8 N18 VSS GTP VDD P L=0.35U W=2U
m9 N18 VDD GTP VSS N L=0.35U W=2U
.ENDS RA1SHD1024X32MWD
****
.SUBCKT RA1SHD1024X32ROW_TOP G0F G1F GTP MBL MBL_ MWL XP0 XP0F XP0_0 XP0_1
+  XP0_2 XP1 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD
** RA1SHD1024X32ROW_TOP: 9 flat devices **
XI5_0 GTP MBL MBL_ MWL XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32MWD
.ENDS RA1SHD1024X32ROW_TOP
****
.SUBCKT RA1SHD1024X32HWDB G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD1024X32HWDB: 30 flat devices **
m1 N25 WD_I0-RSWN0 GTP VDD P L=0.18U W=2.08U
m10 WL0 WD_I0-WL0_EN_ VSS VSS N L=0.18U W=15.71U
m11 N24 WD_I0-RSWN1 GTP VDD P L=0.18U W=2.08U
m12 N24 WD_I0-WLI1 GTP VSS N L=0.18U W=2.08U
m13 N33 G0 VSS VSS N L=0.18U W=1.73U
m14 N34 G1 N33 VSS N L=0.18U W=1.73U
m15 WD_I0-RSWN1 G2_W1 N34 VSS N L=0.18U W=1.73U
m16 WD_I0-RSWN1 G0 VDD VDD P L=0.18U W=1.35U
m17 WD_I0-RSWN1 G2_W1 VDD VDD P L=0.18U W=1.35U
m18 WD_I0-RSWN1 G1 VDD VDD P L=0.18U W=1.35U
m19 WL1 WD_I0-WL1_EN_ VDD VDD P L=0.18U W=30.96U
m2 N25 WD_I0-WLI0 GTP VSS N L=0.18U W=2.08U
m20 WL1 WD_I0-WL1_EN_ VSS VSS N L=0.18U W=15.71U
m21 WD_I0-WLI1 WD_I0-RSWN1 VDD VDD P L=0.18U W=0.61U
m22 WD_I0-WLI1 WD_I0-RSWN1 VSS VSS N L=0.18U W=0.29U
m23 WD_I0-WLI0 WD_I0-RSWN0 VDD VDD P L=0.18U W=0.61U
m24 WD_I0-WLI0 WD_I0-RSWN0 VSS VSS N L=0.18U W=0.29U
m25 N24 WD_I0-RSWN1 VSS VSS N L=0.18U W=2.08U
m26 N25 WD_I0-RSWN0 VSS VSS N L=0.18U W=2.08U
m27 WD_I0-WL1_EN_ N24 VDD VDD P L=0.18U W=14.22U
m28 WD_I0-WL1_EN_ N24 VSS VSS N L=0.18U W=6.66U
m29 WD_I0-WL0_EN_ N25 VDD VDD P L=0.18U W=14.22U
m3 N26 G0 VSS VSS N L=0.18U W=1.73U
m30 WD_I0-WL0_EN_ N25 VSS VSS N L=0.18U W=6.66U
m4 N27 G1 N26 VSS N L=0.18U W=1.73U
m5 WD_I0-RSWN0 G2_W0 N27 VSS N L=0.18U W=1.73U
m6 WD_I0-RSWN0 G0 VDD VDD P L=0.18U W=1.35U
m7 WD_I0-RSWN0 G2_W0 VDD VDD P L=0.18U W=1.35U
m8 WD_I0-RSWN0 G1 VDD VDD P L=0.18U W=1.35U
m9 WL0 WD_I0-WL0_EN_ VDD VDD P L=0.18U W=30.96U
.ENDS RA1SHD1024X32HWDB
****
.SUBCKT RA1SHD1024X32HWDB0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD1024X32HWDB0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD1024X32HWDB
.ENDS RA1SHD1024X32HWDB0
****
.SUBCKT RA1SHD1024X32ROW_BOTTOM G0 G1 GTP WL0 WL1 XP0F XP0F_0 XP0F_1 XP0F_2
+  XP0F_3 XP1F XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SHD1024X32ROW_BOTTOM: 30 flat devices **
XI5_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD1024X32HWDB0
.ENDS RA1SHD1024X32ROW_BOTTOM
****
.SUBCKT RA1SHD1024X32ROW_64 G0 G0B G1 G1B GTP WL0 WL1 XP0F XP0F_0 XP0F_1
+  XP0F_2 XP0F_3 XP1F XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD1024X32ROW_64: 30 flat devices **
XI5_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD1024X32WD0
.ENDS RA1SHD1024X32ROW_64
****
.SUBCKT RA1SHD1024X32WORD_ROWS GTP MBL MBL_ MWL WL0 WL0_0 WL0_1 WL0_2 WL0_3
+  WL0_4 WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11 WL0_12 WL0_13 WL0_14
+  WL0_15 WL0_16 WL0_17 WL0_18 WL0_19 WL0_20 WL0_21 WL0_22 WL0_23 WL0_24
+  WL0_25 WL0_26 WL0_27 WL0_28 WL0_29 WL0_30 WL0_31 WL0_32 WL0_33 WL0_34
+  WL0_35 WL0_36 WL0_37 WL0_38 WL0_39 WL0_40 WL0_41 WL0_42 WL0_43 WL0_44
+  WL0_45 WL0_46 WL0_47 WL0_48 WL0_49 WL0_50 WL0_51 WL0_52 WL0_53 WL0_54
+  WL0_55 WL0_56 WL0_57 WL0_58 WL0_59 WL0_60 WL0_61 WL0_62 WL1 WL1_0 WL1_1
+  WL1_2 WL1_3 WL1_4 WL1_5 WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11 WL1_12 WL1_13
+  WL1_14 WL1_15 WL1_16 WL1_17 WL1_18 WL1_19 WL1_20 WL1_21 WL1_22 WL1_23
+  WL1_24 WL1_25 WL1_26 WL1_27 WL1_28 WL1_29 WL1_30 WL1_31 WL1_32 WL1_33
+  WL1_34 WL1_35 WL1_36 WL1_37 WL1_38 WL1_39 WL1_40 WL1_41 WL1_42 WL1_43
+  WL1_44 WL1_45 WL1_46 WL1_47 WL1_48 WL1_49 WL1_50 WL1_51 WL1_52 WL1_53
+  WL1_54 WL1_55 WL1_56 WL1_57 WL1_58 WL1_59 WL1_60 WL1_61 WL1_62 XP0 XP0_0
+  XP0_1 XP0_2 XP0_3 XP1 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD1024X32WORD_ROWS: 1929 flat devices **
XI0_0 XP0 XP0_3 GTP WL0 WL1 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0 XP1_1 XP1_2
+  XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_BOTTOM
XI0_1 XP0 XP0_3 GTP WL0_0 WL1_0 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_10 XP0 XP0_2 GTP WL0_9 WL1_9 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_11 XP0 XP0_2 GTP WL0_10 WL1_10 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_12 XP0 XP1_2 XP0_2 GTP WL0_11 WL1_11 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_13 XP0 XP1_2 GTP WL0_12 WL1_12 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_14 XP0 XP1_2 GTP WL0_13 WL1_13 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_15 XP0 XP1_2 GTP WL0_14 WL1_14 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_16 XP0 XP0_1 XP1_2 GTP WL0_15 WL1_15 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_17 XP0 XP0_1 GTP WL0_16 WL1_16 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_18 XP0 XP0_1 GTP WL0_17 WL1_17 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_19 XP0 XP0_1 GTP WL0_18 WL1_18 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_2 XP0 XP0_3 GTP WL0_1 WL1_1 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_20 XP0 XP1_1 XP0_1 GTP WL0_19 WL1_19 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_21 XP0 XP1_1 GTP WL0_20 WL1_20 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_22 XP0 XP1_1 GTP WL0_21 WL1_21 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_23 XP0 XP1_1 GTP WL0_22 WL1_22 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_24 XP0 XP0_0 XP1_1 GTP WL0_23 WL1_23 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_25 XP0 XP0_0 GTP WL0_24 WL1_24 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_26 XP0 XP0_0 GTP WL0_25 WL1_25 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_27 XP0 XP0_0 GTP WL0_26 WL1_26 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_28 XP0 XP1_0 XP0_0 GTP WL0_27 WL1_27 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_29 XP0 XP1_0 GTP WL0_28 WL1_28 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_3 XP0 XP0_3 GTP WL0_2 WL1_2 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_30 XP0 XP1_0 GTP WL0_29 WL1_29 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_31 XP0 XP1_0 GTP WL0_30 WL1_30 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_32 XP1 XP0 XP0_3 XP1_0 GTP WL0_31 WL1_31 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD1024X32ROW_64
XI0_33 XP1 XP0_3 GTP WL0_32 WL1_32 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_34 XP1 XP0_3 GTP WL0_33 WL1_33 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_35 XP1 XP0_3 GTP WL0_34 WL1_34 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_36 XP1 XP1_3 XP0_3 GTP WL0_35 WL1_35 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_37 XP1 XP1_3 GTP WL0_36 WL1_36 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_38 XP1 XP1_3 GTP WL0_37 WL1_37 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_39 XP1 XP1_3 GTP WL0_38 WL1_38 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_4 XP0 XP1_3 XP0_3 GTP WL0_3 WL1_3 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_40 XP1 XP0_2 XP1_3 GTP WL0_39 WL1_39 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_41 XP1 XP0_2 GTP WL0_40 WL1_40 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_42 XP1 XP0_2 GTP WL0_41 WL1_41 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_43 XP1 XP0_2 GTP WL0_42 WL1_42 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_44 XP1 XP1_2 XP0_2 GTP WL0_43 WL1_43 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_45 XP1 XP1_2 GTP WL0_44 WL1_44 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_46 XP1 XP1_2 GTP WL0_45 WL1_45 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_47 XP1 XP1_2 GTP WL0_46 WL1_46 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_48 XP1 XP0_1 XP1_2 GTP WL0_47 WL1_47 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_49 XP1 XP0_1 GTP WL0_48 WL1_48 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_5 XP0 XP1_3 GTP WL0_4 WL1_4 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_50 XP1 XP0_1 GTP WL0_49 WL1_49 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_51 XP1 XP0_1 GTP WL0_50 WL1_50 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_52 XP1 XP1_1 XP0_1 GTP WL0_51 WL1_51 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_53 XP1 XP1_1 GTP WL0_52 WL1_52 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_54 XP1 XP1_1 GTP WL0_53 WL1_53 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_55 XP1 XP1_1 GTP WL0_54 WL1_54 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_56 XP1 XP0_0 XP1_1 GTP WL0_55 WL1_55 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_57 XP1 XP0_0 GTP WL0_56 WL1_56 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_58 XP1 XP0_0 GTP WL0_57 WL1_57 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_59 XP1 XP0_0 GTP WL0_58 WL1_58 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_6 XP0 XP1_3 GTP WL0_5 WL1_5 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_60 XP1 XP1_0 XP0_0 GTP WL0_59 WL1_59 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_61 XP1 XP1_0 GTP WL0_60 WL1_60 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
XI0_62 XP1 XP1_0 GTP WL0_61 WL1_61 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER2
XI0_63 XP1 XP1_0 GTP WL0_62 WL1_62 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_64 XP1 XP1_0 GTP MBL MBL_ MWL XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_TOP
XI0_7 XP0 XP1_3 GTP WL0_6 WL1_6 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER3
XI0_8 XP0 XP0_2 XP1_3 GTP WL0_7 WL1_7 XP0 XP0_0 XP0_1 XP0_2 XP0_3 XP1 XP1_0
+  XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_8
XI0_9 XP0 XP0_2 GTP WL0_8 WL1_8 XP0 XP0_3 XP0_0 XP0_1 XP0_2 XP1 XP1_3 XP1_0
+  XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD1024X32ROW_FILLER1
.ENDS RA1SHD1024X32WORD_ROWS
****
.SUBCKT RA1SHD1024X32HCKA A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32HCKA: 9 flat devices **
m1 CK-SRCFEED CK-GTPNSRC VSS VSS N L=0.18U W=29.52U
m2 GTPN CLK CK-GTPFEED VSS N L=0.18U W=9.84U
m3 GTPN RST VDD VDD P L=0.18U W=19.12U
m4 AGTP GTPN VDD VDD P L=0.18U W=42.64U
m5 AGTP GTPN VSS VSS N L=0.18U W=20U
m6 CK-GTPNSRC GSRCN VDD VDD P L=0.18U W=4.48U
m7 CK-GTPNSRC GSRCN VSS VSS N L=0.18U W=2.52U
m8 CK-GTPFEED CLK CK-SRCFEED VSS N L=0.18U W=9.84U
m9 CK-GTPFEED GTPN VDD VSS N L=0.18U W=2.46U
.ENDS RA1SHD1024X32HCKA
****
.SUBCKT RA1SHD1024X32CK A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32CK: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS N L=0.18U W=29.52U
m2 GTPN CLK GTPFEED VSS N L=0.18U W=9.84U
m3 GTPN RST VDD VDD P L=0.18U W=19.12U
m4 GTP GTPN VDD VDD P L=0.18U W=42.64U
m5 GTP GTPN VSS VSS N L=0.18U W=20U
m6 GTPNSRC GSRCN VDD VDD P L=0.18U W=4.48U
m7 GTPNSRC GSRCN VSS VSS N L=0.18U W=2.52U
m8 GTPFEED CLK SRCFEED VSS N L=0.18U W=9.84U
m9 GTPFEED GTPN VDD VSS N L=0.18U W=2.46U
.ENDS RA1SHD1024X32CK
****
.SUBCKT RA1SHD1024X32CLK_DRVS A0 A0_ AGTP CLK GSRCN GTP GTPN GTP_0 GTP_1 GTP_2
+  RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32CLK_DRVS: 45 flat devices **
XI0_0 A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SHD1024X32HCKA
XI1_0 A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SHD1024X32CK
XI2_0 A0 A0_ CLK GSRCN GTP_0 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD1024X32CK
XI3_0 A0 A0_ CLK GSRCN GTP_1 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD1024X32CK
XI4_0 A0 A0_ CLK GSRCN GTP_2 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD1024X32CK
.ENDS RA1SHD1024X32CLK_DRVS
****
.SUBCKT RA1SHD1024X32WING_16_RIGHT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42
+  BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54
+  BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66
+  BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78
+  BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90
+  BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102
+  BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112
+  BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122
+  BL_123 BL_124 BL_125 BL_126 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BWEN BWEN_0 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11
+  D_12 D_13 D_14 GTP GTP_0 GTP_1 OE_ Q Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8
+  Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW
+  STUBDW_ STUBDW_0 STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD
** RA1SHD1024X32WING_16_RIGHT: 102722 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1 OE_ Q STUBDR_67 STUBDR__65
+  STUBDR_0 STUBDR__0 STUBDW_69 STUBDW__71 STUBDW_0 STUBDW__0 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76
+  WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88
+  WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100
+  WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110
+  WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120
+  WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32MCOL_EVEN_LE8
XI10_0 A0 A0_ BL_63 BL__63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL__64
+  BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BWEN_0 D_7 GTP GTP_0 GTP_1 OE_
+  Q_7 STUBDR_3 STUBDR__1 STUBDR_0_11 STUBDR__0_9 STUBDW_5 STUBDW__7
+  STUBDW_0_13 STUBDW__0_15 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_LE8
XI11_0 A0 A0_ BL_78 BL__78 BL_77 BL_76 BL_75 BL_74 BL_73 BL_72 BL_71 BL__77
+  BL__76 BL__75 BL__74 BL__73 BL__72 BL__71 BWEN_0 D_8 GTP GTP_0 GTP_1 OE_
+  Q_8 STUBDR_3 STUBDR__1 STUBDR_0_19 STUBDR__0_17 STUBDW_5 STUBDW__7
+  STUBDW_0_21 STUBDW__0_23 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_M8
XI12_0 A0 A0_ BL_79 BL__79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BWEN_0 D_9 GTP GTP_0 GTP_1 OE_
+  Q_9 STUBDR_27 STUBDR__25 STUBDR_0_19 STUBDR__0_17 STUBDW_29 STUBDW__31
+  STUBDW_0_21 STUBDW__0_23 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_M8
XI13_0 A0 A0_ BL_94 BL__94 BL_93 BL_92 BL_91 BL_90 BL_89 BL_88 BL_87 BL__93
+  BL__92 BL__91 BL__90 BL__89 BL__88 BL__87 BWEN_0 D_10 GTP GTP_0 GTP_1 OE_
+  Q_10 STUBDR_27 STUBDR__25 STUBDR_0_35 STUBDR__0_33 STUBDW_29 STUBDW__31
+  STUBDW_0_37 STUBDW__0_39 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_M8
XI15_0 A0 A0_ BL_95 BL__95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BWEN_0 D_11 GTP GTP_0 GTP_1
+  OE_ Q_11 STUBDR_43 STUBDR__41 STUBDR_0_35 STUBDR__0_33 STUBDW_45 STUBDW__47
+  STUBDW_0_37 STUBDW__0_39 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_M8
XI16_0 A0 A0_ BL_110 BL__110 BL_109 BL_108 BL_107 BL_106 BL_105 BL_104 BL_103
+  BL__109 BL__108 BL__107 BL__106 BL__105 BL__104 BL__103 BWEN_0 D_12 GTP
+  GTP_0 GTP_1 OE_ Q_12 STUBDR_43 STUBDR__41 STUBDR_0_51 STUBDR__0_49
+  STUBDW_45 STUBDW__47 STUBDW_0_53 STUBDW__0_55 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD1024X32MCOL_ODD_M8
XI17_0 A0 A0_ BL_111 BL__111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118
+  BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 BWEN_0 D_13 GTP
+  GTP_0 GTP_1 OE_ Q_13 STUBDR_59 STUBDR__57 STUBDR_0_51 STUBDR__0_49
+  STUBDW_61 STUBDW__63 STUBDW_0_53 STUBDW__0_55 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD1024X32MCOL_EVEN_M8
XI18_0 A0 A0_ BL_126 BL__126 BL_125 BL_124 BL_123 BL_122 BL_121 BL_120 BL_119
+  BL__125 BL__124 BL__123 BL__122 BL__121 BL__120 BL__119 BWEN_0 D_14 GTP
+  GTP_0 GTP_1 OE_ Q_14 STUBDR_59 STUBDR__57 STUBDR STUBDR_ STUBDW_61
+  STUBDW__63 STUBDW STUBDW_ WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_RO8
XI1_0 A0 A0_ BL_14 BL__14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL_7 BL__13 BL__12
+  BL__11 BL__10 BL__9 BL__8 BL__7 BWEN D_0 GTP GTP_0 GTP_1 OE_ Q_0 STUBDR_67
+  STUBDR__65 STUBDR_0_75 STUBDR__0_73 STUBDW_69 STUBDW__71 STUBDW_0_77
+  STUBDW__0_79 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD1024X32MCOL_ODD_M8
XI2_0 A0 A0_ BL_15 BL__15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BWEN D_1 GTP GTP_0 GTP_1 OE_ Q_1
+  STUBDR_83 STUBDR__81 STUBDR_0_75 STUBDR__0_73 STUBDW_85 STUBDW__87
+  STUBDW_0_77 STUBDW__0_79 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_M8
XI3_0 A0 A0_ BL_30 BL__30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL__29
+  BL__28 BL__27 BL__26 BL__25 BL__24 BL__23 BWEN D_2 GTP GTP_0 GTP_1 OE_ Q_2
+  STUBDR_83 STUBDR__81 STUBDR_0_91 STUBDR__0_89 STUBDW_85 STUBDW__87
+  STUBDW_0_93 STUBDW__0_95 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_M8
XI5_0 A0 A0_ BL_31 BL__31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL__32
+  BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BWEN D_3 GTP GTP_0 GTP_1 OE_ Q_3
+  STUBDR_99 STUBDR__97 STUBDR_0_91 STUBDR__0_89 STUBDW_101 STUBDW__103
+  STUBDW_0_93 STUBDW__0_95 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_M8
XI6_0 A0 A0_ BL_46 BL__46 BL_45 BL_44 BL_43 BL_42 BL_41 BL_40 BL_39 BL__45
+  BL__44 BL__43 BL__42 BL__41 BL__40 BL__39 BWEN D_4 GTP GTP_0 GTP_1 OE_ Q_4
+  STUBDR_99 STUBDR__97 STUBDR_0_107 STUBDR__0_105 STUBDW_101 STUBDW__103
+  STUBDW_0_109 STUBDW__0_111 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_M8
XI7_0 A0 A0_ BL_47 BL__47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BWEN D_5 GTP GTP_0 GTP_1 OE_ Q_5
+  STUBDR_115 STUBDR__113 STUBDR_0_107 STUBDR__0_105 STUBDW_117 STUBDW__119
+  STUBDW_0_109 STUBDW__0_111 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_EVEN_M8
XI8_0 A0 A0_ BL_62 BL__62 BL_61 BL_60 BL_59 BL_58 BL_57 BL_56 BL_55 BL__61
+  BL__60 BL__59 BL__58 BL__57 BL__56 BL__55 BWEN D_6 GTP GTP_0 GTP_1 OE_ Q_6
+  STUBDR_115 STUBDR__113 STUBDR_0_11 STUBDR__0_9 STUBDW_117 STUBDW__119
+  STUBDW_0_13 STUBDW__0_15 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32MCOL_ODD_RO8
.ENDS RA1SHD1024X32WING_16_RIGHT
****
.SUBCKT RA1SHD1024X32FLCIO A0 A0_ CLK GSRCN GTP GTPN MBL MBL_ RST YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32FLCIO: 11 flat devices **
d1 VSS GTP DN 0.3364P 2.32U
d10 VSS A0_ DN 0.3364P 2.32U
d11 VSS A0 DN 0.3364P 2.32U
d2 VSS YP0_0 DN 0.3364P 2.32U
d3 VSS YP1_0 DN 0.3364P 2.32U
d4 VSS YP0_1 DN 0.3364P 2.32U
d5 VSS YP0_2 DN 0.3364P 2.32U
d6 VSS YP0_3 DN 0.3364P 2.32U
d7 VSS YP1_1 DN 0.3364P 2.32U
d8 VSS YP1_2 DN 0.3364P 2.32U
d9 VSS YP1_3 DN 0.3364P 2.32U
.ENDS RA1SHD1024X32FLCIO
****
.SUBCKT RA1SHD1024X32FCCDR A0 A0_ GTP VD YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32FCCDR: 2 flat devices **
d2 VSS VSS DN 0.3364P 2.32U
m1 VDD VSS VD VDD P L=0.18U W=0.22U
.ENDS RA1SHD1024X32FCCDR
****
.SUBCKT RA1SHD1024X32RIGHT_CAP A0 A0_ GTP GTP_0 GTP_1 OE_ WE WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD1024X32RIGHT_CAP: 792 flat devices **
XI0_0 GTP OE_ WE VSS VDD RA1SHD1024X32FCIO8
XI0_1 GTP_0 VSS VDD RA1SHD1024X32FCSA8
XI0_10 BL BL WL_6 WL_6 VSS VDD RA1SHD1024X32CCG
XI0_100 BL BL WL_96 WL_96 VSS VDD RA1SHD1024X32CCG
XI0_101 BL BL WL_97 WL_97 VSS VDD RA1SHD1024X32CCG
XI0_102 BL BL WL_98 WL_98 VSS VDD RA1SHD1024X32CCG
XI0_103 BL BL WL_99 WL_99 VSS VDD RA1SHD1024X32CCG
XI0_104 BL BL WL_100 WL_100 VSS VDD RA1SHD1024X32CCG
XI0_105 BL BL WL_101 WL_101 VSS VDD RA1SHD1024X32CCG
XI0_106 BL BL WL_102 WL_102 VSS VDD RA1SHD1024X32CCG
XI0_107 BL BL WL_103 WL_103 VSS VDD RA1SHD1024X32CCG
XI0_108 BL BL WL_104 WL_104 VSS VDD RA1SHD1024X32CCG
XI0_109 BL BL WL_105 WL_105 VSS VDD RA1SHD1024X32CCG
XI0_11 BL BL WL_7 WL_7 VSS VDD RA1SHD1024X32CCG
XI0_110 BL BL WL_106 WL_106 VSS VDD RA1SHD1024X32CCG
XI0_111 BL BL WL_107 WL_107 VSS VDD RA1SHD1024X32CCG
XI0_112 BL BL WL_108 WL_108 VSS VDD RA1SHD1024X32CCG
XI0_113 BL BL WL_109 WL_109 VSS VDD RA1SHD1024X32CCG
XI0_114 BL BL WL_110 WL_110 VSS VDD RA1SHD1024X32CCG
XI0_115 BL BL WL_111 WL_111 VSS VDD RA1SHD1024X32CCG
XI0_116 BL BL WL_112 WL_112 VSS VDD RA1SHD1024X32CCG
XI0_117 BL BL WL_113 WL_113 VSS VDD RA1SHD1024X32CCG
XI0_118 BL BL WL_114 WL_114 VSS VDD RA1SHD1024X32CCG
XI0_119 BL BL WL_115 WL_115 VSS VDD RA1SHD1024X32CCG
XI0_12 BL BL WL_8 WL_8 VSS VDD RA1SHD1024X32CCG
XI0_120 BL BL WL_116 WL_116 VSS VDD RA1SHD1024X32CCG
XI0_121 BL BL WL_117 WL_117 VSS VDD RA1SHD1024X32CCG
XI0_122 BL BL WL_118 WL_118 VSS VDD RA1SHD1024X32CCG
XI0_123 BL BL WL_119 WL_119 VSS VDD RA1SHD1024X32CCG
XI0_124 BL BL WL_120 WL_120 VSS VDD RA1SHD1024X32CCG
XI0_125 BL BL WL_121 WL_121 VSS VDD RA1SHD1024X32CCG
XI0_126 BL BL WL_122 WL_122 VSS VDD RA1SHD1024X32CCG
XI0_127 BL BL WL_123 WL_123 VSS VDD RA1SHD1024X32CCG
XI0_128 BL BL WL_124 WL_124 VSS VDD RA1SHD1024X32CCG
XI0_129 BL BL WL_125 WL_125 VSS VDD RA1SHD1024X32CCG
XI0_13 BL BL WL_9 WL_9 VSS VDD RA1SHD1024X32CCG
XI0_130 BL BL WL_126 WL_126 VSS VDD RA1SHD1024X32CCG
XI0_131 BL BL VSS VSS VSS VDD RA1SHD1024X32CCG
XI0_132 BL BL VSS VSS VSS VDD RA1SHD1024X32CCG
XI0_133 BL BL VSS VSS VSS VDD RA1SHD1024X32CCG
XI0_14 BL BL WL_10 WL_10 VSS VDD RA1SHD1024X32CCG
XI0_15 BL BL WL_11 WL_11 VSS VDD RA1SHD1024X32CCG
XI0_16 BL BL WL_12 WL_12 VSS VDD RA1SHD1024X32CCG
XI0_17 BL BL WL_13 WL_13 VSS VDD RA1SHD1024X32CCG
XI0_18 BL BL WL_14 WL_14 VSS VDD RA1SHD1024X32CCG
XI0_19 BL BL WL_15 WL_15 VSS VDD RA1SHD1024X32CCG
XI0_2 A0 A0_ GTP_1 BL YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD1024X32FCCDR
XI0_20 BL BL WL_16 WL_16 VSS VDD RA1SHD1024X32CCG
XI0_21 BL BL WL_17 WL_17 VSS VDD RA1SHD1024X32CCG
XI0_22 BL BL WL_18 WL_18 VSS VDD RA1SHD1024X32CCG
XI0_23 BL BL WL_19 WL_19 VSS VDD RA1SHD1024X32CCG
XI0_24 BL BL WL_20 WL_20 VSS VDD RA1SHD1024X32CCG
XI0_25 BL BL WL_21 WL_21 VSS VDD RA1SHD1024X32CCG
XI0_26 BL BL WL_22 WL_22 VSS VDD RA1SHD1024X32CCG
XI0_27 BL BL WL_23 WL_23 VSS VDD RA1SHD1024X32CCG
XI0_28 BL BL WL_24 WL_24 VSS VDD RA1SHD1024X32CCG
XI0_29 BL BL WL_25 WL_25 VSS VDD RA1SHD1024X32CCG
XI0_3 BL BL WL WL VSS VDD RA1SHD1024X32CCG
XI0_30 BL BL WL_26 WL_26 VSS VDD RA1SHD1024X32CCG
XI0_31 BL BL WL_27 WL_27 VSS VDD RA1SHD1024X32CCG
XI0_32 BL BL WL_28 WL_28 VSS VDD RA1SHD1024X32CCG
XI0_33 BL BL WL_29 WL_29 VSS VDD RA1SHD1024X32CCG
XI0_34 BL BL WL_30 WL_30 VSS VDD RA1SHD1024X32CCG
XI0_35 BL BL WL_31 WL_31 VSS VDD RA1SHD1024X32CCG
XI0_36 BL BL WL_32 WL_32 VSS VDD RA1SHD1024X32CCG
XI0_37 BL BL WL_33 WL_33 VSS VDD RA1SHD1024X32CCG
XI0_38 BL BL WL_34 WL_34 VSS VDD RA1SHD1024X32CCG
XI0_39 BL BL WL_35 WL_35 VSS VDD RA1SHD1024X32CCG
XI0_4 BL BL WL_0 WL_0 VSS VDD RA1SHD1024X32CCG
XI0_40 BL BL WL_36 WL_36 VSS VDD RA1SHD1024X32CCG
XI0_41 BL BL WL_37 WL_37 VSS VDD RA1SHD1024X32CCG
XI0_42 BL BL WL_38 WL_38 VSS VDD RA1SHD1024X32CCG
XI0_43 BL BL WL_39 WL_39 VSS VDD RA1SHD1024X32CCG
XI0_44 BL BL WL_40 WL_40 VSS VDD RA1SHD1024X32CCG
XI0_45 BL BL WL_41 WL_41 VSS VDD RA1SHD1024X32CCG
XI0_46 BL BL WL_42 WL_42 VSS VDD RA1SHD1024X32CCG
XI0_47 BL BL WL_43 WL_43 VSS VDD RA1SHD1024X32CCG
XI0_48 BL BL WL_44 WL_44 VSS VDD RA1SHD1024X32CCG
XI0_49 BL BL WL_45 WL_45 VSS VDD RA1SHD1024X32CCG
XI0_5 BL BL WL_1 WL_1 VSS VDD RA1SHD1024X32CCG
XI0_50 BL BL WL_46 WL_46 VSS VDD RA1SHD1024X32CCG
XI0_51 BL BL WL_47 WL_47 VSS VDD RA1SHD1024X32CCG
XI0_52 BL BL WL_48 WL_48 VSS VDD RA1SHD1024X32CCG
XI0_53 BL BL WL_49 WL_49 VSS VDD RA1SHD1024X32CCG
XI0_54 BL BL WL_50 WL_50 VSS VDD RA1SHD1024X32CCG
XI0_55 BL BL WL_51 WL_51 VSS VDD RA1SHD1024X32CCG
XI0_56 BL BL WL_52 WL_52 VSS VDD RA1SHD1024X32CCG
XI0_57 BL BL WL_53 WL_53 VSS VDD RA1SHD1024X32CCG
XI0_58 BL BL WL_54 WL_54 VSS VDD RA1SHD1024X32CCG
XI0_59 BL BL WL_55 WL_55 VSS VDD RA1SHD1024X32CCG
XI0_6 BL BL WL_2 WL_2 VSS VDD RA1SHD1024X32CCG
XI0_60 BL BL WL_56 WL_56 VSS VDD RA1SHD1024X32CCG
XI0_61 BL BL WL_57 WL_57 VSS VDD RA1SHD1024X32CCG
XI0_62 BL BL WL_58 WL_58 VSS VDD RA1SHD1024X32CCG
XI0_63 BL BL WL_59 WL_59 VSS VDD RA1SHD1024X32CCG
XI0_64 BL BL WL_60 WL_60 VSS VDD RA1SHD1024X32CCG
XI0_65 BL BL WL_61 WL_61 VSS VDD RA1SHD1024X32CCG
XI0_66 BL BL WL_62 WL_62 VSS VDD RA1SHD1024X32CCG
XI0_67 BL BL WL_63 WL_63 VSS VDD RA1SHD1024X32CCG
XI0_68 BL BL WL_64 WL_64 VSS VDD RA1SHD1024X32CCG
XI0_69 BL BL WL_65 WL_65 VSS VDD RA1SHD1024X32CCG
XI0_7 BL BL WL_3 WL_3 VSS VDD RA1SHD1024X32CCG
XI0_70 BL BL WL_66 WL_66 VSS VDD RA1SHD1024X32CCG
XI0_71 BL BL WL_67 WL_67 VSS VDD RA1SHD1024X32CCG
XI0_72 BL BL WL_68 WL_68 VSS VDD RA1SHD1024X32CCG
XI0_73 BL BL WL_69 WL_69 VSS VDD RA1SHD1024X32CCG
XI0_74 BL BL WL_70 WL_70 VSS VDD RA1SHD1024X32CCG
XI0_75 BL BL WL_71 WL_71 VSS VDD RA1SHD1024X32CCG
XI0_76 BL BL WL_72 WL_72 VSS VDD RA1SHD1024X32CCG
XI0_77 BL BL WL_73 WL_73 VSS VDD RA1SHD1024X32CCG
XI0_78 BL BL WL_74 WL_74 VSS VDD RA1SHD1024X32CCG
XI0_79 BL BL WL_75 WL_75 VSS VDD RA1SHD1024X32CCG
XI0_8 BL BL WL_4 WL_4 VSS VDD RA1SHD1024X32CCG
XI0_80 BL BL WL_76 WL_76 VSS VDD RA1SHD1024X32CCG
XI0_81 BL BL WL_77 WL_77 VSS VDD RA1SHD1024X32CCG
XI0_82 BL BL WL_78 WL_78 VSS VDD RA1SHD1024X32CCG
XI0_83 BL BL WL_79 WL_79 VSS VDD RA1SHD1024X32CCG
XI0_84 BL BL WL_80 WL_80 VSS VDD RA1SHD1024X32CCG
XI0_85 BL BL WL_81 WL_81 VSS VDD RA1SHD1024X32CCG
XI0_86 BL BL WL_82 WL_82 VSS VDD RA1SHD1024X32CCG
XI0_87 BL BL WL_83 WL_83 VSS VDD RA1SHD1024X32CCG
XI0_88 BL BL WL_84 WL_84 VSS VDD RA1SHD1024X32CCG
XI0_89 BL BL WL_85 WL_85 VSS VDD RA1SHD1024X32CCG
XI0_9 BL BL WL_5 WL_5 VSS VDD RA1SHD1024X32CCG
XI0_90 BL BL WL_86 WL_86 VSS VDD RA1SHD1024X32CCG
XI0_91 BL BL WL_87 WL_87 VSS VDD RA1SHD1024X32CCG
XI0_92 BL BL WL_88 WL_88 VSS VDD RA1SHD1024X32CCG
XI0_93 BL BL WL_89 WL_89 VSS VDD RA1SHD1024X32CCG
XI0_94 BL BL WL_90 WL_90 VSS VDD RA1SHD1024X32CCG
XI0_95 BL BL WL_91 WL_91 VSS VDD RA1SHD1024X32CCG
XI0_96 BL BL WL_92 WL_92 VSS VDD RA1SHD1024X32CCG
XI0_97 BL BL WL_93 WL_93 VSS VDD RA1SHD1024X32CCG
XI0_98 BL BL WL_94 WL_94 VSS VDD RA1SHD1024X32CCG
XI0_99 BL BL WL_95 WL_95 VSS VDD RA1SHD1024X32CCG
.ENDS RA1SHD1024X32RIGHT_CAP
****
.SUBCKT RA1SHD1024X32CCMBT MBL MBL_ TIEDOWN WL VSS VDD
** RA1SHD1024X32CCMBT: 6 flat devices **
m1 MBL TIEDOWN CORED VSS N L=0.29U W=0.22U
m2 MBL_ TIEDOWN CORED_ VSS N L=0.29U W=0.22U
m3 CORED_ CORED VDD VDD P L=0.19U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.25U
m5 CORED CORED_ VDD VDD P L=0.19U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.25U
.ENDS RA1SHD1024X32CCMBT
****
.SUBCKT RA1SHD1024X32CCMBB MBL MBL_ TIEDOWN WL VSS VDD
** RA1SHD1024X32CCMBB: 6 flat devices **
m1 MBL TIEDOWN CORED VSS N L=0.29U W=0.22U
m2 MBL_ TIEDOWN CORED_ VSS N L=0.29U W=0.22U
m3 CORED_ CORED VDD VDD P L=0.19U W=0.22U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.25U
m5 CORED CORED_ VDD VDD P L=0.19U W=0.22U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.25U
.ENDS RA1SHD1024X32CCMBB
****
.SUBCKT RA1SHD1024X32CCPDBB GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** RA1SHD1024X32CCPDBB: 5 flat devices **
m1 MBL MWL CORED VSS N L=0.29U W=0.22U
m2 MBL_ MWL N9 VSS N L=0.29U W=0.22U
m3 CORED GTP VSS VSS N L=0.18U W=0.25U
m4 N10 GTP VDD VDD P L=0.19U W=0.22U
m5 N12 CORED VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD1024X32CCPDBB
****
.SUBCKT RA1SHD1024X32CCPDT GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** RA1SHD1024X32CCPDT: 5 flat devices **
m1 MBL MWL N9 VSS N L=0.29U W=0.22U
m2 MBL_ MWL CORED_ VSS N L=0.29U W=0.22U
m3 CORED_ GTP VSS VSS N L=0.18U W=0.25U
m4 N11 GTP VDD VDD P L=0.19U W=0.22U
m5 N13 CORED_ VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD1024X32CCPDT
****
.SUBCKT RA1SHD1024X32CCPDB GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** RA1SHD1024X32CCPDB: 5 flat devices **
m1 MBL MWL CORED VSS N L=0.29U W=0.22U
m2 MBL_ MWL N9 VSS N L=0.29U W=0.22U
m3 CORED GTP VSS VSS N L=0.18U W=0.25U
m4 N10 GTP VDD VDD P L=0.19U W=0.22U
m5 N12 CORED VDD VDD P L=0.19U W=0.22U
.ENDS RA1SHD1024X32CCPDB
****
.SUBCKT RA1SHD1024X32MBLBASE GTP MBL MBL_ MWLD MWLS VSS VDD
** RA1SHD1024X32MBLBASE: 12 flat devices **
m1 N13 GTP VSS VSS N L=0.18U W=0.25U
m10 MBL MWLD NODE7 VSS N L=0.29U W=0.22U
m11 NODE8 GTP VSS VSS N L=0.18U W=0.25U
m12 MBL MWLD NODE8 VSS N L=0.29U W=0.22U
m2 MBL MWLD N13 VSS N L=0.29U W=0.22U
m3 NODE3 GTP VSS VSS N L=0.18U W=0.25U
m4 MBL MWLD NODE3 VSS N L=0.29U W=0.22U
m5 NODE4 GTP VSS VSS N L=0.18U W=0.25U
m6 MBL MWLD NODE4 VSS N L=0.29U W=0.22U
m7 NODE6 GTP VSS VSS N L=0.18U W=0.25U
m8 MBL MWLD NODE6 VSS N L=0.29U W=0.22U
m9 NODE7 GTP VSS VSS N L=0.18U W=0.25U
.ENDS RA1SHD1024X32MBLBASE
****
.SUBCKT RA1SHD1024X32MODEL_COL GTP MBL MBL_ MWLD MWLS WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76
+  WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88
+  WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100
+  WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110
+  WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120
+  WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 VSS VDD
** RA1SHD1024X32MODEL_COL: 758 flat devices **
XI0_0 MBL MBL_ VSS WL VSS VDD RA1SHD1024X32CCMBB
XI0_1 MBL_ MBL VSS WL_0 VSS VDD RA1SHD1024X32CCMBT
XI0_10 MBL MBL_ VSS WL_9 VSS VDD RA1SHD1024X32CCMBB
XI0_100 MBL MBL_ VSS WL_99 VSS VDD RA1SHD1024X32CCMBB
XI0_101 MBL_ MBL VSS WL_100 VSS VDD RA1SHD1024X32CCMBT
XI0_102 MBL MBL_ VSS WL_101 VSS VDD RA1SHD1024X32CCMBB
XI0_103 MBL_ MBL VSS WL_102 VSS VDD RA1SHD1024X32CCMBT
XI0_104 MBL MBL_ VSS WL_103 VSS VDD RA1SHD1024X32CCMBB
XI0_105 MBL_ MBL VSS WL_104 VSS VDD RA1SHD1024X32CCMBT
XI0_106 GTP MBL MBL_ MWLD VSS WL_105 VSS VDD RA1SHD1024X32CCPDBB
XI0_107 GTP MBL_ MBL MWLD VSS WL_106 VSS VDD RA1SHD1024X32CCPDT
XI0_108 GTP MBL MBL_ MWLD VSS WL_107 VSS VDD RA1SHD1024X32CCPDB
XI0_109 GTP MBL_ MBL MWLD VSS WL_108 VSS VDD RA1SHD1024X32CCPDT
XI0_11 MBL_ MBL VSS WL_10 VSS VDD RA1SHD1024X32CCMBT
XI0_110 GTP MBL MBL_ MWLD VSS WL_109 VSS VDD RA1SHD1024X32CCPDB
XI0_111 GTP MBL_ MBL MWLD VSS WL_110 VSS VDD RA1SHD1024X32CCPDT
XI0_112 GTP MBL MBL_ MWLD VSS WL_111 VSS VDD RA1SHD1024X32CCPDB
XI0_113 GTP MBL_ MBL MWLD VSS WL_112 VSS VDD RA1SHD1024X32CCPDT
XI0_114 GTP MBL MBL_ MWLD VSS WL_113 VSS VDD RA1SHD1024X32CCPDB
XI0_115 GTP MBL_ MBL MWLD VSS WL_114 VSS VDD RA1SHD1024X32CCPDT
XI0_116 GTP MBL MBL_ MWLD VSS WL_115 VSS VDD RA1SHD1024X32CCPDB
XI0_117 GTP MBL_ MBL MWLD VSS WL_116 VSS VDD RA1SHD1024X32CCPDT
XI0_118 GTP MBL MBL_ MWLD VSS WL_117 VSS VDD RA1SHD1024X32CCPDB
XI0_119 GTP MBL_ MBL MWLD VSS WL_118 VSS VDD RA1SHD1024X32CCPDT
XI0_12 MBL MBL_ VSS WL_11 VSS VDD RA1SHD1024X32CCMBB
XI0_120 GTP MBL MBL_ MWLD VSS WL_119 VSS VDD RA1SHD1024X32CCPDB
XI0_121 GTP MBL_ MBL MWLD VSS WL_120 VSS VDD RA1SHD1024X32CCPDT
XI0_122 GTP MBL MBL_ MWLD VSS WL_121 VSS VDD RA1SHD1024X32CCPDB
XI0_123 GTP MBL_ MBL MWLD VSS WL_122 VSS VDD RA1SHD1024X32CCPDT
XI0_124 GTP MBL MBL_ MWLD VSS WL_123 VSS VDD RA1SHD1024X32CCPDB
XI0_125 GTP MBL_ MBL MWLD VSS WL_124 VSS VDD RA1SHD1024X32CCPDT
XI0_126 GTP MBL MBL_ MWLD VSS WL_125 VSS VDD RA1SHD1024X32CCPDB
XI0_127 GTP MBL_ MBL MWLD VSS WL_126 VSS VDD RA1SHD1024X32CCPDT
XI0_128 GTP MBL MBL_ MWLD MWLS VSS VDD RA1SHD1024X32MBLBASE
XI0_13 MBL_ MBL VSS WL_12 VSS VDD RA1SHD1024X32CCMBT
XI0_14 MBL MBL_ VSS WL_13 VSS VDD RA1SHD1024X32CCMBB
XI0_15 MBL_ MBL VSS WL_14 VSS VDD RA1SHD1024X32CCMBT
XI0_16 MBL MBL_ VSS WL_15 VSS VDD RA1SHD1024X32CCMBB
XI0_17 MBL_ MBL VSS WL_16 VSS VDD RA1SHD1024X32CCMBT
XI0_18 MBL MBL_ VSS WL_17 VSS VDD RA1SHD1024X32CCMBB
XI0_19 MBL_ MBL VSS WL_18 VSS VDD RA1SHD1024X32CCMBT
XI0_2 MBL MBL_ VSS WL_1 VSS VDD RA1SHD1024X32CCMBB
XI0_20 MBL MBL_ VSS WL_19 VSS VDD RA1SHD1024X32CCMBB
XI0_21 MBL_ MBL VSS WL_20 VSS VDD RA1SHD1024X32CCMBT
XI0_22 MBL MBL_ VSS WL_21 VSS VDD RA1SHD1024X32CCMBB
XI0_23 MBL_ MBL VSS WL_22 VSS VDD RA1SHD1024X32CCMBT
XI0_24 MBL MBL_ VSS WL_23 VSS VDD RA1SHD1024X32CCMBB
XI0_25 MBL_ MBL VSS WL_24 VSS VDD RA1SHD1024X32CCMBT
XI0_26 MBL MBL_ VSS WL_25 VSS VDD RA1SHD1024X32CCMBB
XI0_27 MBL_ MBL VSS WL_26 VSS VDD RA1SHD1024X32CCMBT
XI0_28 MBL MBL_ VSS WL_27 VSS VDD RA1SHD1024X32CCMBB
XI0_29 MBL_ MBL VSS WL_28 VSS VDD RA1SHD1024X32CCMBT
XI0_3 MBL_ MBL VSS WL_2 VSS VDD RA1SHD1024X32CCMBT
XI0_30 MBL MBL_ VSS WL_29 VSS VDD RA1SHD1024X32CCMBB
XI0_31 MBL_ MBL VSS WL_30 VSS VDD RA1SHD1024X32CCMBT
XI0_32 MBL MBL_ VSS WL_31 VSS VDD RA1SHD1024X32CCMBB
XI0_33 MBL_ MBL VSS WL_32 VSS VDD RA1SHD1024X32CCMBT
XI0_34 MBL MBL_ VSS WL_33 VSS VDD RA1SHD1024X32CCMBB
XI0_35 MBL_ MBL VSS WL_34 VSS VDD RA1SHD1024X32CCMBT
XI0_36 MBL MBL_ VSS WL_35 VSS VDD RA1SHD1024X32CCMBB
XI0_37 MBL_ MBL VSS WL_36 VSS VDD RA1SHD1024X32CCMBT
XI0_38 MBL MBL_ VSS WL_37 VSS VDD RA1SHD1024X32CCMBB
XI0_39 MBL_ MBL VSS WL_38 VSS VDD RA1SHD1024X32CCMBT
XI0_4 MBL MBL_ VSS WL_3 VSS VDD RA1SHD1024X32CCMBB
XI0_40 MBL MBL_ VSS WL_39 VSS VDD RA1SHD1024X32CCMBB
XI0_41 MBL_ MBL VSS WL_40 VSS VDD RA1SHD1024X32CCMBT
XI0_42 MBL MBL_ VSS WL_41 VSS VDD RA1SHD1024X32CCMBB
XI0_43 MBL_ MBL VSS WL_42 VSS VDD RA1SHD1024X32CCMBT
XI0_44 MBL MBL_ VSS WL_43 VSS VDD RA1SHD1024X32CCMBB
XI0_45 MBL_ MBL VSS WL_44 VSS VDD RA1SHD1024X32CCMBT
XI0_46 MBL MBL_ VSS WL_45 VSS VDD RA1SHD1024X32CCMBB
XI0_47 MBL_ MBL VSS WL_46 VSS VDD RA1SHD1024X32CCMBT
XI0_48 MBL MBL_ VSS WL_47 VSS VDD RA1SHD1024X32CCMBB
XI0_49 MBL_ MBL VSS WL_48 VSS VDD RA1SHD1024X32CCMBT
XI0_5 MBL_ MBL VSS WL_4 VSS VDD RA1SHD1024X32CCMBT
XI0_50 MBL MBL_ VSS WL_49 VSS VDD RA1SHD1024X32CCMBB
XI0_51 MBL_ MBL VSS WL_50 VSS VDD RA1SHD1024X32CCMBT
XI0_52 MBL MBL_ VSS WL_51 VSS VDD RA1SHD1024X32CCMBB
XI0_53 MBL_ MBL VSS WL_52 VSS VDD RA1SHD1024X32CCMBT
XI0_54 MBL MBL_ VSS WL_53 VSS VDD RA1SHD1024X32CCMBB
XI0_55 MBL_ MBL VSS WL_54 VSS VDD RA1SHD1024X32CCMBT
XI0_56 MBL MBL_ VSS WL_55 VSS VDD RA1SHD1024X32CCMBB
XI0_57 MBL_ MBL VSS WL_56 VSS VDD RA1SHD1024X32CCMBT
XI0_58 MBL MBL_ VSS WL_57 VSS VDD RA1SHD1024X32CCMBB
XI0_59 MBL_ MBL VSS WL_58 VSS VDD RA1SHD1024X32CCMBT
XI0_6 MBL MBL_ VSS WL_5 VSS VDD RA1SHD1024X32CCMBB
XI0_60 MBL MBL_ VSS WL_59 VSS VDD RA1SHD1024X32CCMBB
XI0_61 MBL_ MBL VSS WL_60 VSS VDD RA1SHD1024X32CCMBT
XI0_62 MBL MBL_ VSS WL_61 VSS VDD RA1SHD1024X32CCMBB
XI0_63 MBL_ MBL VSS WL_62 VSS VDD RA1SHD1024X32CCMBT
XI0_64 MBL MBL_ VSS WL_63 VSS VDD RA1SHD1024X32CCMBB
XI0_65 MBL_ MBL VSS WL_64 VSS VDD RA1SHD1024X32CCMBT
XI0_66 MBL MBL_ VSS WL_65 VSS VDD RA1SHD1024X32CCMBB
XI0_67 MBL_ MBL VSS WL_66 VSS VDD RA1SHD1024X32CCMBT
XI0_68 MBL MBL_ VSS WL_67 VSS VDD RA1SHD1024X32CCMBB
XI0_69 MBL_ MBL VSS WL_68 VSS VDD RA1SHD1024X32CCMBT
XI0_7 MBL_ MBL VSS WL_6 VSS VDD RA1SHD1024X32CCMBT
XI0_70 MBL MBL_ VSS WL_69 VSS VDD RA1SHD1024X32CCMBB
XI0_71 MBL_ MBL VSS WL_70 VSS VDD RA1SHD1024X32CCMBT
XI0_72 MBL MBL_ VSS WL_71 VSS VDD RA1SHD1024X32CCMBB
XI0_73 MBL_ MBL VSS WL_72 VSS VDD RA1SHD1024X32CCMBT
XI0_74 MBL MBL_ VSS WL_73 VSS VDD RA1SHD1024X32CCMBB
XI0_75 MBL_ MBL VSS WL_74 VSS VDD RA1SHD1024X32CCMBT
XI0_76 MBL MBL_ VSS WL_75 VSS VDD RA1SHD1024X32CCMBB
XI0_77 MBL_ MBL VSS WL_76 VSS VDD RA1SHD1024X32CCMBT
XI0_78 MBL MBL_ VSS WL_77 VSS VDD RA1SHD1024X32CCMBB
XI0_79 MBL_ MBL VSS WL_78 VSS VDD RA1SHD1024X32CCMBT
XI0_8 MBL MBL_ VSS WL_7 VSS VDD RA1SHD1024X32CCMBB
XI0_80 MBL MBL_ VSS WL_79 VSS VDD RA1SHD1024X32CCMBB
XI0_81 MBL_ MBL VSS WL_80 VSS VDD RA1SHD1024X32CCMBT
XI0_82 MBL MBL_ VSS WL_81 VSS VDD RA1SHD1024X32CCMBB
XI0_83 MBL_ MBL VSS WL_82 VSS VDD RA1SHD1024X32CCMBT
XI0_84 MBL MBL_ VSS WL_83 VSS VDD RA1SHD1024X32CCMBB
XI0_85 MBL_ MBL VSS WL_84 VSS VDD RA1SHD1024X32CCMBT
XI0_86 MBL MBL_ VSS WL_85 VSS VDD RA1SHD1024X32CCMBB
XI0_87 MBL_ MBL VSS WL_86 VSS VDD RA1SHD1024X32CCMBT
XI0_88 MBL MBL_ VSS WL_87 VSS VDD RA1SHD1024X32CCMBB
XI0_89 MBL_ MBL VSS WL_88 VSS VDD RA1SHD1024X32CCMBT
XI0_9 MBL_ MBL VSS WL_8 VSS VDD RA1SHD1024X32CCMBT
XI0_90 MBL MBL_ VSS WL_89 VSS VDD RA1SHD1024X32CCMBB
XI0_91 MBL_ MBL VSS WL_90 VSS VDD RA1SHD1024X32CCMBT
XI0_92 MBL MBL_ VSS WL_91 VSS VDD RA1SHD1024X32CCMBB
XI0_93 MBL_ MBL VSS WL_92 VSS VDD RA1SHD1024X32CCMBT
XI0_94 MBL MBL_ VSS WL_93 VSS VDD RA1SHD1024X32CCMBB
XI0_95 MBL_ MBL VSS WL_94 VSS VDD RA1SHD1024X32CCMBT
XI0_96 MBL MBL_ VSS WL_95 VSS VDD RA1SHD1024X32CCMBB
XI0_97 MBL_ MBL VSS WL_96 VSS VDD RA1SHD1024X32CCMBT
XI0_98 MBL MBL_ VSS WL_97 VSS VDD RA1SHD1024X32CCMBB
XI0_99 MBL_ MBL VSS WL_98 VSS VDD RA1SHD1024X32CCMBT
.ENDS RA1SHD1024X32MODEL_COL
****
.SUBCKT RA1SHD1024X32 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] CEN
+  CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12]
+  D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23] D[24]
+  D[25] D[26] D[27] D[28] D[29] D[30] D[31] OEN Q[0] Q[1] Q[2] Q[3] Q[4] Q[5]
+  Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17] Q[18]
+  Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] Q[28] Q[29] Q[30]
+  Q[31] WEN[0] WEN[1] WEN[2] WEN[3] VSS VDD
** RA1SHD1024X32: 215096 flat devices **
XI0_0 A0 A0_ DR DR_ DW DW_ GTP_1 GTP_1 GTP_1 OE_ VSS WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76
+  WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88
+  WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100
+  WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110
+  WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120
+  WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS
+  VSS VSS VSS VDD RA1SHD1024X32LEFT_CAP
XI1_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22
+  BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34
+  BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46
+  BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58
+  BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70
+  BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82
+  BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94
+  BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105
+  BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115
+  BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125
+  BL_126 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 WEN[1]
+  WEN[0] D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5] D[4]
+  D[3] D[2] D[1] D[0] GTP_1 GTP_1 GTP_1 OE_ Q[15] Q[14] Q[13] Q[12] Q[11]
+  Q[10] Q[9] Q[8] Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] DR DR_ VSS VSS DW
+  DW_ VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD
+  RA1SHD1024X32WING_16_LEFT
XI1_5 BL_ BL__63 BL_63 BL__64 BL_64 BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__15 BL__16 BL__17
+  BL__18 BL__19 BL__20 BL__21 BL__22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28
+  BL_29 BL_30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL_39
+  BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62
+  BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BL_71 BL_72 BL_73 BL_74 BL_75
+  BL_76 BL_77 BL_78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108
+  BL_109 BL_110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117
+  BL__118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_0 BL_1
+  BL_2 BL_3 BL_4 BL_5 BL_6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13
+  BL__14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__23 BL__24 BL__25
+  BL__26 BL__27 BL__28 BL__29 BL__30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL_47
+  BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL__71
+  BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL_79 BL_80 BL_81 BL_82
+  BL_83 BL_84 BL_85 BL_86 BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93
+  BL__94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL__103 BL__104
+  BL__105 BL__106 BL__107 BL__108 BL__109 BL__110 BL_111 BL_112 BL_113 BL_114
+  BL_115 BL_116 BL_117 BL_118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124
+  BL__125 BL__126 MWLB VSS VSS VDD RA1SHD1024X32MODEL_ROW_16
XI3_0 A[9] A[6] A[3] A[7] A[4] A[8] A[5] AGTPT AGTPT A0 A0_ VSS OE_ VSS XP_0
+  XP_0_0 XP_0_1 XP_1 XP_1_0 XP_1_1 XP_2 XP_2_0 XP_3 XP_3_0 XP_4 XP_4_0 XP_5
+  XP_5_0 XP_6 XP_6_0 XP_7 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS
+  VDD RA1SHD1024X32X_PRE_DECODE
XI3_3 GTP_1 MBL MBL_ MWLB WL WL_2 WL_3 WL_6 WL_7 WL_10 WL_11 WL_14 WL_15 WL_18
+  WL_19 WL_22 WL_23 WL_26 WL_27 WL_30 WL_31 WL_34 WL_35 WL_38 WL_39 WL_42
+  WL_43 WL_46 WL_47 WL_50 WL_51 WL_54 WL_55 WL_58 WL_59 WL_62 WL_63 WL_66
+  WL_67 WL_70 WL_71 WL_74 WL_75 WL_78 WL_79 WL_82 WL_83 WL_86 WL_87 WL_90
+  WL_91 WL_94 WL_95 WL_98 WL_99 WL_102 WL_103 WL_106 WL_107 WL_110 WL_111
+  WL_114 WL_115 WL_118 WL_119 WL_122 WL_123 WL_126 WL_0 WL_1 WL_4 WL_5 WL_8
+  WL_9 WL_12 WL_13 WL_16 WL_17 WL_20 WL_21 WL_24 WL_25 WL_28 WL_29 WL_32
+  WL_33 WL_36 WL_37 WL_40 WL_41 WL_44 WL_45 WL_48 WL_49 WL_52 WL_53 WL_56
+  WL_57 WL_60 WL_61 WL_64 WL_65 WL_68 WL_69 WL_72 WL_73 WL_76 WL_77 WL_80
+  WL_81 WL_84 WL_85 WL_88 WL_89 WL_92 WL_93 WL_96 WL_97 WL_100 WL_101 WL_104
+  WL_105 WL_108 WL_109 WL_112 WL_113 WL_116 WL_117 WL_120 WL_121 WL_124
+  WL_125 XP_0 XP_6 XP_4 XP_2 XP_0_0 XP_1 XP_7 XP_5 XP_3 XP_1_0 XP_0_1 XP_1_1
+  XP_2_0 XP_3_0 XP_4_0 XP_5_0 XP_6_0 XP_7_0 VSS VDD RA1SHD1024X32WORD_ROWS
XI4_0 A[1] A[0] A[2] AGTPT A0 A0_ VSS CLK GSRCN GTPN OE_ RST VSS YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VDD RA1SHD1024X32Y_DECODE
XI5_0 CEN CEN_ CLK GSRCN GTP_1 GTPN MBL OE_ OEN OEN_ RST VSS WE VSS WEN_ VSS
+  VDD RA1SHD1024X32HBFX
XI5_2 A0 A0_ AGTPT CLK GSRCN GTP_1 GTPN GTP_1 GTP_1 GTP_1 RST YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD RA1SHD1024X32CLK_DRVS
XI6_2 A0 A0_ CLK GSRCN GTP_1 GTPN MBL MBL_ RST YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS
+  VSS VSS VSS VDD RA1SHD1024X32FLCIO
XI6_4 GTP_1 MBL MBL_ MWLB MWLB WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 VSS VDD RA1SHD1024X32MODEL_COL
XI7_0 A0 A0_ BL_933 BL__935 BL_0_929 BL_1_925 BL_2_921 BL_3_917 BL_4_913
+  BL_5_909 BL_6_905 BL_7_903 BL_8_899 BL_9_895 BL_10_891 BL_11_887 BL_12_883
+  BL_13_879 BL_14_875 BL_15_869 BL_16_865 BL_17_861 BL_18_857 BL_19_853
+  BL_20_849 BL_21_845 BL_22_841 BL_23_839 BL_24_835 BL_25_831 BL_26_827
+  BL_27_823 BL_28_819 BL_29_815 BL_30_811 BL_31_805 BL_32_801 BL_33_797
+  BL_34_793 BL_35_789 BL_36_785 BL_37_781 BL_38_777 BL_39_775 BL_40_771
+  BL_41_767 BL_42_763 BL_43_759 BL_44_755 BL_45_751 BL_46_747 BL_47_741
+  BL_48_737 BL_49_733 BL_50_729 BL_51_725 BL_52_721 BL_53_717 BL_54_713
+  BL_55_711 BL_56_707 BL_57_703 BL_58_699 BL_59_695 BL_60_691 BL_61_687
+  BL_62_683 BL_63_677 BL_64_673 BL_65_669 BL_66_665 BL_67_661 BL_68_657
+  BL_69_653 BL_70_649 BL_71_647 BL_72_643 BL_73_639 BL_74_635 BL_75_631
+  BL_76_627 BL_77_623 BL_78_619 BL_79_613 BL_80_609 BL_81_605 BL_82_601
+  BL_83_597 BL_84_593 BL_85_589 BL_86_585 BL_87_583 BL_88_579 BL_89_575
+  BL_90_571 BL_91_567 BL_92_563 BL_93_559 BL_94_555 BL_95_549 BL_96_545
+  BL_97_541 BL_98_537 BL_99_533 BL_100_529 BL_101_525 BL_102_521 BL_103_519
+  BL_104_515 BL_105_511 BL_106_507 BL_107_503 BL_108_499 BL_109_495
+  BL_110_491 BL_111_485 BL_112_481 BL_113_477 BL_114_473 BL_115_469
+  BL_116_465 BL_117_461 BL_118_457 BL_119_455 BL_120_451 BL_121_447
+  BL_122_443 BL_123_439 BL_124_435 BL_125_431 BL_126_427 BL__0_931 BL__1_927
+  BL__2_923 BL__3_919 BL__4_915 BL__5_911 BL__6_907 BL__7_901 BL__8_897
+  BL__9_893 BL__10_889 BL__11_885 BL__12_881 BL__13_877 BL__14_873 BL__15_871
+  BL__16_867 BL__17_863 BL__18_859 BL__19_855 BL__20_851 BL__21_847
+  BL__22_843 BL__23_837 BL__24_833 BL__25_829 BL__26_825 BL__27_821
+  BL__28_817 BL__29_813 BL__30_809 BL__31_807 BL__32_803 BL__33_799
+  BL__34_795 BL__35_791 BL__36_787 BL__37_783 BL__38_779 BL__39_773
+  BL__40_769 BL__41_765 BL__42_761 BL__43_757 BL__44_753 BL__45_749
+  BL__46_745 BL__47_743 BL__48_739 BL__49_735 BL__50_731 BL__51_727
+  BL__52_723 BL__53_719 BL__54_715 BL__55_709 BL__56_705 BL__57_701
+  BL__58_697 BL__59_693 BL__60_689 BL__61_685 BL__62_681 BL__63_679
+  BL__64_675 BL__65_671 BL__66_667 BL__67_663 BL__68_659 BL__69_655
+  BL__70_651 BL__71_645 BL__72_641 BL__73_637 BL__74_633 BL__75_629
+  BL__76_625 BL__77_621 BL__78_617 BL__79_615 BL__80_611 BL__81_607
+  BL__82_603 BL__83_599 BL__84_595 BL__85_591 BL__86_587 BL__87_581
+  BL__88_577 BL__89_573 BL__90_569 BL__91_565 BL__92_561 BL__93_557
+  BL__94_553 BL__95_551 BL__96_547 BL__97_543 BL__98_539 BL__99_535
+  BL__100_531 BL__101_527 BL__102_523 BL__103_517 BL__104_513 BL__105_509
+  BL__106_505 BL__107_501 BL__108_497 BL__109_493 BL__110_489 BL__111_487
+  BL__112_483 BL__113_479 BL__114_475 BL__115_471 BL__116_467 BL__117_463
+  BL__118_459 BL__119_453 BL__120_449 BL__121_445 BL__122_441 BL__123_437
+  BL__124_433 BL__125_429 BL__126_425 WEN[2] WEN[3] D[16] D[17] D[18] D[19]
+  D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29] D[30] D[31]
+  GTP_1 GTP_1 GTP_1 OE_ Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24]
+  Q[25] Q[26] Q[27] Q[28] Q[29] Q[30] Q[31] VSS VSS STUBDR_0 STUBDR__0 VSS
+  VSS STUBDW_0 STUBDW__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD
+  RA1SHD1024X32WING_16_RIGHT
XI7_5 BL__935 BL__63_679 BL_63_677 BL__64_675 BL_64_673 BL_933 BL__0_931
+  BL__1_927 BL__2_923 BL__3_919 BL__4_915 BL__5_911 BL__6_907 BL_7_903
+  BL_8_899 BL_9_895 BL_10_891 BL_11_887 BL_12_883 BL_13_879 BL_14_875
+  BL__15_871 BL__16_867 BL__17_863 BL__18_859 BL__19_855 BL__20_851
+  BL__21_847 BL__22_843 BL_23_839 BL_24_835 BL_25_831 BL_26_827 BL_27_823
+  BL_28_819 BL_29_815 BL_30_811 BL__31_807 BL__32_803 BL__33_799 BL__34_795
+  BL__35_791 BL__36_787 BL__37_783 BL__38_779 BL_39_775 BL_40_771 BL_41_767
+  BL_42_763 BL_43_759 BL_44_755 BL_45_751 BL_46_747 BL__47_743 BL__48_739
+  BL__49_735 BL__50_731 BL__51_727 BL__52_723 BL__53_719 BL__54_715 BL_55_711
+  BL_56_707 BL_57_703 BL_58_699 BL_59_695 BL_60_691 BL_61_687 BL_62_683
+  BL__65_671 BL__66_667 BL__67_663 BL__68_659 BL__69_655 BL__70_651 BL_71_647
+  BL_72_643 BL_73_639 BL_74_635 BL_75_631 BL_76_627 BL_77_623 BL_78_619
+  BL__79_615 BL__80_611 BL__81_607 BL__82_603 BL__83_599 BL__84_595
+  BL__85_591 BL__86_587 BL_87_583 BL_88_579 BL_89_575 BL_90_571 BL_91_567
+  BL_92_563 BL_93_559 BL_94_555 BL__95_551 BL__96_547 BL__97_543 BL__98_539
+  BL__99_535 BL__100_531 BL__101_527 BL__102_523 BL_103_519 BL_104_515
+  BL_105_511 BL_106_507 BL_107_503 BL_108_499 BL_109_495 BL_110_491
+  BL__111_487 BL__112_483 BL__113_479 BL__114_475 BL__115_471 BL__116_467
+  BL__117_463 BL__118_459 BL_119_455 BL_120_451 BL_121_447 BL_122_443
+  BL_123_439 BL_124_435 BL_125_431 BL_126_427 BL_0_929 BL_1_925 BL_2_921
+  BL_3_917 BL_4_913 BL_5_909 BL_6_905 BL__7_901 BL__8_897 BL__9_893
+  BL__10_889 BL__11_885 BL__12_881 BL__13_877 BL__14_873 BL_15_869 BL_16_865
+  BL_17_861 BL_18_857 BL_19_853 BL_20_849 BL_21_845 BL_22_841 BL__23_837
+  BL__24_833 BL__25_829 BL__26_825 BL__27_821 BL__28_817 BL__29_813
+  BL__30_809 BL_31_805 BL_32_801 BL_33_797 BL_34_793 BL_35_789 BL_36_785
+  BL_37_781 BL_38_777 BL__39_773 BL__40_769 BL__41_765 BL__42_761 BL__43_757
+  BL__44_753 BL__45_749 BL__46_745 BL_47_741 BL_48_737 BL_49_733 BL_50_729
+  BL_51_725 BL_52_721 BL_53_717 BL_54_713 BL__55_709 BL__56_705 BL__57_701
+  BL__58_697 BL__59_693 BL__60_689 BL__61_685 BL__62_681 BL_65_669 BL_66_665
+  BL_67_661 BL_68_657 BL_69_653 BL_70_649 BL__71_645 BL__72_641 BL__73_637
+  BL__74_633 BL__75_629 BL__76_625 BL__77_621 BL__78_617 BL_79_613 BL_80_609
+  BL_81_605 BL_82_601 BL_83_597 BL_84_593 BL_85_589 BL_86_585 BL__87_581
+  BL__88_577 BL__89_573 BL__90_569 BL__91_565 BL__92_561 BL__93_557
+  BL__94_553 BL_95_549 BL_96_545 BL_97_541 BL_98_537 BL_99_533 BL_100_529
+  BL_101_525 BL_102_521 BL__103_517 BL__104_513 BL__105_509 BL__106_505
+  BL__107_501 BL__108_497 BL__109_493 BL__110_489 BL_111_485 BL_112_481
+  BL_113_477 BL_114_473 BL_115_469 BL_116_465 BL_117_461 BL_118_457
+  BL__119_453 BL__120_449 BL__121_445 BL__122_441 BL__123_437 BL__124_433
+  BL__125_429 BL__126_425 MWLB VSS VSS VDD RA1SHD1024X32MODEL_ROW_16
XI8_0 A0 A0_ GTP_1 GTP_1 GTP_1 OE_ VSS WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD
+  RA1SHD1024X32RIGHT_CAP
.ENDS RA1SHD1024X32
